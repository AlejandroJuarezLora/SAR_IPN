* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT sar_logic clk rstn en comp cal valid result_0_ result_1_ result_2_ result_3_ result_4_ result_5_ result_6_ result_7_ sample ctlp_0_ ctlp_1_ ctlp_2_ ctlp_3_ ctlp_4_ ctlp_5_ ctlp_6_ ctlp_7_ ctln_0_ ctln_1_ ctln_2_ ctln_3_ ctln_4_ ctln_5_ ctln_6_ ctln_7_ trim_0_ trim_1_ trim_2_ trim_3_ trim_4_ trimb_0_ trimb_1_ trimb_2_ trimb_3_ trimb_4_ clkc
X0 1 state_0_ _NC0 _NC1 _NC2 _NC3 sky130_fd_sc_hd__clkinv_1
X1 2 en _NC4 _NC5 _NC6 _NC7 sky130_fd_sc_hd__clkinv_1
X2 valid state_0_ state_1_ state_2_ _NC8 _NC9 _NC10 _NC11 sky130_fd_sc_hd__nor3b_1
X3 3 state_1_ state_0_ _NC12 _NC13 _NC14 _NC15 sky130_fd_sc_hd__lpflow_isobufsrc_1
X4 4 state_1_ state_2_ state_0_ _NC16 _NC17 _NC18 _NC19 sky130_fd_sc_hd__and3b_1
X5 5 state_1_ state_2_ state_0_ _NC20 _NC21 _NC22 _NC23 sky130_fd_sc_hd__nand3b_1
X6 6 state_0_ state_2_ _NC24 _NC25 _NC26 _NC27 sky130_fd_sc_hd__nor2_1
X7 7 state_1_ 6 _NC28 _NC29 _NC30 _NC31 sky130_fd_sc_hd__nand2_1
X8 sample 5 7 _NC32 _NC33 _NC34 _NC35 sky130_fd_sc_hd__nand2_1
X9 trimb_0_ trim_mask_0_ trim_val_0_ _NC36 _NC37 _NC38 _NC39 sky130_fd_sc_hd__nor2_1
X10 trim_0_ trimb_0_ _NC40 _NC41 _NC42 _NC43 sky130_fd_sc_hd__clkinv_1
X11 trimb_1_ trim_val_1_ trim_mask_1_ _NC44 _NC45 _NC46 _NC47 sky130_fd_sc_hd__nor2_1
X12 trim_1_ trimb_1_ _NC48 _NC49 _NC50 _NC51 sky130_fd_sc_hd__clkinv_1
X13 trimb_2_ trim_val_2_ trim_mask_2_ _NC52 _NC53 _NC54 _NC55 sky130_fd_sc_hd__nor2_1
X14 trim_2_ trimb_2_ _NC56 _NC57 _NC58 _NC59 sky130_fd_sc_hd__clkinv_1
X15 trimb_3_ trim_val_3_ trim_mask_3_ _NC60 _NC61 _NC62 _NC63 sky130_fd_sc_hd__nor2_1
X16 trim_3_ trimb_3_ _NC64 _NC65 _NC66 _NC67 sky130_fd_sc_hd__clkinv_1
X17 trimb_4_ trim_val_4_ trim_mask_4_ _NC68 _NC69 _NC70 _NC71 sky130_fd_sc_hd__nor2_1
X18 trim_4_ trimb_4_ _NC72 _NC73 _NC74 _NC75 sky130_fd_sc_hd__clkinv_1
X19 ctln_0_ mask_0_ result_0_ _NC76 _NC77 _NC78 _NC79 sky130_fd_sc_hd__nor2_1
X20 ctlp_0_ ctln_0_ _NC80 _NC81 _NC82 _NC83 sky130_fd_sc_hd__clkinv_1
X21 ctln_1_ mask_1_ result_1_ _NC84 _NC85 _NC86 _NC87 sky130_fd_sc_hd__nor2_1
X22 ctlp_1_ ctln_1_ _NC88 _NC89 _NC90 _NC91 sky130_fd_sc_hd__clkinv_1
X23 ctln_2_ mask_2_ result_2_ _NC92 _NC93 _NC94 _NC95 sky130_fd_sc_hd__nor2_1
X24 ctlp_2_ ctln_2_ _NC96 _NC97 _NC98 _NC99 sky130_fd_sc_hd__clkinv_1
X25 ctln_3_ mask_3_ result_3_ _NC100 _NC101 _NC102 _NC103 sky130_fd_sc_hd__nor2_1
X26 ctlp_3_ ctln_3_ _NC104 _NC105 _NC106 _NC107 sky130_fd_sc_hd__clkinv_1
X27 ctln_4_ mask_4_ result_4_ _NC108 _NC109 _NC110 _NC111 sky130_fd_sc_hd__nor2_1
X28 ctlp_4_ ctln_4_ _NC112 _NC113 _NC114 _NC115 sky130_fd_sc_hd__clkinv_1
X29 ctln_5_ mask_5_ result_5_ _NC116 _NC117 _NC118 _NC119 sky130_fd_sc_hd__nor2_1
X30 ctlp_5_ ctln_5_ _NC120 _NC121 _NC122 _NC123 sky130_fd_sc_hd__clkinv_1
X31 ctln_6_ mask_6_ result_6_ _NC124 _NC125 _NC126 _NC127 sky130_fd_sc_hd__nor2_1
X32 ctlp_6_ ctln_6_ _NC128 _NC129 _NC130 _NC131 sky130_fd_sc_hd__clkinv_1
X33 ctln_7_ mask_7_ result_7_ _NC132 _NC133 _NC134 _NC135 sky130_fd_sc_hd__nor2_1
X34 ctlp_7_ ctln_7_ _NC136 _NC137 _NC138 _NC139 sky130_fd_sc_hd__clkinv_1
X35 8 cal_itt_0_ cal_itt_1_ _NC140 _NC141 _NC142 _NC143 sky130_fd_sc_hd__nand2_1
X36 9 cal_itt_3_ cal_itt_0_ cal_itt_1_ cal_itt_2_ _NC144 _NC145 _NC146 _NC147 sky130_fd_sc_hd__and4b_1
X37 10 trim_mask_0_ 9 _NC148 _NC149 _NC150 _NC151 sky130_fd_sc_hd__nand2_1
X38 11 cal_itt_0_ 10 5 _NC152 _NC153 _NC154 _NC155 sky130_fd_sc_hd__a21oi_1
X39 12 state_2_ en 3 _NC156 _NC157 _NC158 _NC159 sky130_fd_sc_hd__o21ai_0
X40 13 12 _NC160 _NC161 _NC162 _NC163 sky130_fd_sc_hd__clkinv_1
X41 14 cal_itt_0_ 12 11 _NC164 _NC165 _NC166 _NC167 sky130_fd_sc_hd__a21o_1
X42 15 cal_itt_0_ cal_itt_1_ _NC168 _NC169 _NC170 _NC171 sky130_fd_sc_hd__nor2_1
X43 16 cal_itt_1_ 12 _NC172 _NC173 _NC174 _NC175 sky130_fd_sc_hd__nand2_1
X44 17 trim_mask_0_ 9 8 _NC176 _NC177 _NC178 _NC179 sky130_fd_sc_hd__a21oi_1
X45 18 5 15 17 16 _NC180 _NC181 _NC182 _NC183 sky130_fd_sc_hd__o31ai_1
X46 19 cal_itt_2_ 8 _NC184 _NC185 _NC186 _NC187 sky130_fd_sc_hd__xor2_1
X47 20 10 19 5 _NC188 _NC189 _NC190 _NC191 sky130_fd_sc_hd__a21oi_1
X48 21 cal_itt_2_ 12 20 _NC192 _NC193 _NC194 _NC195 sky130_fd_sc_hd__a21o_1
X49 22 cal_itt_0_ cal_itt_1_ cal_itt_2_ 5 _NC196 _NC197 _NC198 _NC199 sky130_fd_sc_hd__a31oi_1
X50 23 12 22 cal_itt_3_ _NC200 _NC201 _NC202 _NC203 sky130_fd_sc_hd__o21a_1
X51 24 5 9 _NC204 _NC205 _NC206 _NC207 sky130_fd_sc_hd__lpflow_inputiso1p_1
X52 25 state_2_ state_0_ _NC208 _NC209 _NC210 _NC211 sky130_fd_sc_hd__lpflow_isobufsrc_1
X53 26 state_2_ state_1_ state_0_ _NC212 _NC213 _NC214 _NC215 sky130_fd_sc_hd__nor3b_1
X54 27 en 26 _NC216 _NC217 _NC218 _NC219 sky130_fd_sc_hd__and2_0
X55 28 cal_count_0_ 24 27 _NC220 _NC221 _NC222 _NC223 sky130_fd_sc_hd__a21oi_1
X56 29 cal_count_0_ 5 28 _NC224 _NC225 _NC226 _NC227 sky130_fd_sc_hd__o21ai_0
X57 30 cal_count_0_ cal_count_1_ comp _NC228 _NC229 _NC230 _NC231 sky130_fd_sc_hd__a21boi_0
X58 31 cal_count_0_ cal_count_1_ _NC232 _NC233 _NC234 _NC235 sky130_fd_sc_hd__nor2_1
X59 32 comp cal_count_0_ cal_count_1_ _NC236 _NC237 _NC238 _NC239 sky130_fd_sc_hd__and3b_1
X60 33 30 31 32 _NC240 _NC241 _NC242 _NC243 sky130_fd_sc_hd__nor3_1
X61 34 cal_count_0_ cal_count_1_ comp _NC244 _NC245 _NC246 _NC247 sky130_fd_sc_hd__nor3b_1
X62 35 24 33 34 13 cal_count_1_ _NC248 _NC249 _NC250 _NC251 sky130_fd_sc_hd__o32a_1
X63 36 32 34 _NC252 _NC253 _NC254 _NC255 sky130_fd_sc_hd__nor2_1
X64 37 cal_count_2_ 36 24 _NC256 _NC257 _NC258 _NC259 sky130_fd_sc_hd__o21ba_1
X65 38 24 36 cal_count_2_ _NC260 _NC261 _NC262 _NC263 sky130_fd_sc_hd__o21ai_0
X66 39 12 37 38 _NC264 _NC265 _NC266 _NC267 sky130_fd_sc_hd__o21ai_0
X67 40 cal_count_3_ 12 _NC268 _NC269 _NC270 _NC271 sky130_fd_sc_hd__nand2_1
X68 41 34 32 cal_count_2_ _NC272 _NC273 _NC274 _NC275 sky130_fd_sc_hd__mux2i_1
X69 42 cal_count_3_ 41 _NC276 _NC277 _NC278 _NC279 sky130_fd_sc_hd__xor2_1
X70 43 24 42 40 _NC280 _NC281 _NC282 _NC283 sky130_fd_sc_hd__o21ai_0
X71 44 en_co_clk 27 _NC284 _NC285 _NC286 _NC287 sky130_fd_sc_hd__nor2_1
X72 45 trim_mask_0_ 9 5 _NC288 _NC289 _NC290 _NC291 sky130_fd_sc_hd__a21oi_1
X73 46 3 25 _NC292 _NC293 _NC294 _NC295 sky130_fd_sc_hd__nor2_1
X74 47 en_co_clk 46 _NC296 _NC297 _NC298 _NC299 sky130_fd_sc_hd__nand2_1
X75 48 state_2_ state_1_ state_0_ _NC300 _NC301 _NC302 _NC303 sky130_fd_sc_hd__and3b_1
X76 49 mask_0_ 48 _NC304 _NC305 _NC306 _NC307 sky130_fd_sc_hd__lpflow_isobufsrc_1
X77 50 26 45 49 _NC308 _NC309 _NC310 _NC311 sky130_fd_sc_hd__nor3_1
X78 51 47 50 44 _NC312 _NC313 _NC314 _NC315 sky130_fd_sc_hd__a21oi_1
X79 52 4 9 _NC316 _NC317 _NC318 _NC319 sky130_fd_sc_hd__and2_0
X80 53 4 9 _NC320 _NC321 _NC322 _NC323 sky130_fd_sc_hd__nand2_1
X81 54 state_0_ state_2_ state_1_ _NC324 _NC325 _NC326 _NC327 sky130_fd_sc_hd__nor3_1
X82 55 state_1_ calibrate 6 _NC328 _NC329 _NC330 _NC331 sky130_fd_sc_hd__and3_1
X83 56 54 55 _NC332 _NC333 _NC334 _NC335 sky130_fd_sc_hd__lpflow_inputiso1p_1
X84 57 trim_mask_0_ cal_count_3_ 52 trim_val_0_ _NC336 _NC337 _NC338 _NC339 sky130_fd_sc_hd__a31oi_1
X85 58 56 57 _NC340 _NC341 _NC342 _NC343 sky130_fd_sc_hd__nor2_1
X86 59 cal_count_3_ 52 trim_val_1_ _NC344 _NC345 _NC346 _NC347 sky130_fd_sc_hd__a21oi_1
X87 60 trimb_1_ 56 59 _NC348 _NC349 _NC350 _NC351 sky130_fd_sc_hd__nor3_1
X88 61 cal_count_3_ 52 trim_val_2_ _NC352 _NC353 _NC354 _NC355 sky130_fd_sc_hd__a21oi_1
X89 62 trimb_2_ 56 61 _NC356 _NC357 _NC358 _NC359 sky130_fd_sc_hd__nor3_1
X90 63 cal_count_3_ 52 trim_val_3_ _NC360 _NC361 _NC362 _NC363 sky130_fd_sc_hd__a21oi_1
X91 64 trimb_3_ 56 63 _NC364 _NC365 _NC366 _NC367 sky130_fd_sc_hd__nor3_1
X92 65 55 trim_val_4_ _NC368 _NC369 _NC370 _NC371 sky130_fd_sc_hd__lpflow_isobufsrc_1
X93 66 cal_count_3_ trim_mask_4_ 52 54 65 _NC372 _NC373 _NC374 _NC375 sky130_fd_sc_hd__a311o_1
X94 67 4 55 24 _NC376 _NC377 _NC378 _NC379 sky130_fd_sc_hd__o21ai_0
X95 68 trim_mask_1_ 52 67 trim_mask_0_ _NC380 _NC381 _NC382 _NC383 sky130_fd_sc_hd__a22o_1
X96 69 trim_mask_2_ 52 67 trim_mask_1_ _NC384 _NC385 _NC386 _NC387 sky130_fd_sc_hd__a22o_1
X97 70 trim_mask_3_ 52 67 trim_mask_2_ _NC388 _NC389 _NC390 _NC391 sky130_fd_sc_hd__a22o_1
X98 71 trim_mask_4_ 52 67 trim_mask_3_ _NC392 _NC393 _NC394 _NC395 sky130_fd_sc_hd__a22o_1
X99 72 trim_mask_4_ 53 55 _NC396 _NC397 _NC398 _NC399 sky130_fd_sc_hd__a21o_1
X100 73 state_1_ en 25 _NC400 _NC401 _NC402 _NC403 sky130_fd_sc_hd__o21ai_0
X101 74 mask_1_ 48 73 mask_0_ _NC404 _NC405 _NC406 _NC407 sky130_fd_sc_hd__a22o_1
X102 75 mask_2_ 48 73 mask_1_ _NC408 _NC409 _NC410 _NC411 sky130_fd_sc_hd__a22o_1
X103 76 mask_3_ 48 73 mask_2_ _NC412 _NC413 _NC414 _NC415 sky130_fd_sc_hd__a22o_1
X104 77 mask_4_ 48 73 mask_3_ _NC416 _NC417 _NC418 _NC419 sky130_fd_sc_hd__a22o_1
X105 78 mask_5_ 48 73 mask_4_ _NC420 _NC421 _NC422 _NC423 sky130_fd_sc_hd__a22o_1
X106 79 mask_6_ 48 73 mask_5_ _NC424 _NC425 _NC426 _NC427 sky130_fd_sc_hd__a22o_1
X107 80 mask_7_ 48 73 mask_6_ _NC428 _NC429 _NC430 _NC431 sky130_fd_sc_hd__a22o_1
X108 81 mask_7_ 27 _NC432 _NC433 _NC434 _NC435 sky130_fd_sc_hd__nor2_1
X109 82 48 81 _NC436 _NC437 _NC438 _NC439 sky130_fd_sc_hd__nor2_1
X110 83 state_2_ state_1_ state_0_ _NC440 _NC441 _NC442 _NC443 sky130_fd_sc_hd__a21oi_1
X111 84 state_2_ state_1_ _NC444 _NC445 _NC446 _NC447 sky130_fd_sc_hd__nand2_1
X112 85 state_2_ state_1_ 45 _NC448 _NC449 _NC450 _NC451 sky130_fd_sc_hd__a21oi_1
X113 86 2 26 49 83 _NC452 _NC453 _NC454 _NC455 sky130_fd_sc_hd__a211oi_1
X114 87 trim_mask_0_ 53 85 1 86 _NC456 _NC457 _NC458 _NC459 sky130_fd_sc_hd__o221ai_1
X115 88 27 49 _NC460 _NC461 _NC462 _NC463 sky130_fd_sc_hd__nor2_1
X116 89 calibrate 7 84 88 _NC464 _NC465 _NC466 _NC467 sky130_fd_sc_hd__o211ai_1
X117 90 mask_0_ 48 55 4 _NC468 _NC469 _NC470 _NC471 sky130_fd_sc_hd__a211oi_1
X118 91 84 90 _NC472 _NC473 _NC474 _NC475 sky130_fd_sc_hd__nand2_1
X119 92 cal 27 _NC476 _NC477 _NC478 _NC479 sky130_fd_sc_hd__nand2_1
X120 93 12 45 calibrate _NC480 _NC481 _NC482 _NC483 sky130_fd_sc_hd__o21ai_0
X121 94 92 93 _NC484 _NC485 _NC486 _NC487 sky130_fd_sc_hd__nand2_1
X122 95 comp 48 _NC488 _NC489 _NC490 _NC491 sky130_fd_sc_hd__and2_0
X123 96 mask_0_ 95 result_0_ _NC492 _NC493 _NC494 _NC495 sky130_fd_sc_hd__a21oi_1
X124 97 27 96 _NC496 _NC497 _NC498 _NC499 sky130_fd_sc_hd__nor2_1
X125 98 mask_1_ 95 result_1_ _NC500 _NC501 _NC502 _NC503 sky130_fd_sc_hd__a21oi_1
X126 99 27 98 _NC504 _NC505 _NC506 _NC507 sky130_fd_sc_hd__nor2_1
X127 100 mask_2_ 95 result_2_ _NC508 _NC509 _NC510 _NC511 sky130_fd_sc_hd__a21oi_1
X128 101 27 100 _NC512 _NC513 _NC514 _NC515 sky130_fd_sc_hd__nor2_1
X129 102 mask_3_ 95 result_3_ _NC516 _NC517 _NC518 _NC519 sky130_fd_sc_hd__a21oi_1
X130 103 27 102 _NC520 _NC521 _NC522 _NC523 sky130_fd_sc_hd__nor2_1
X131 104 mask_4_ 95 result_4_ _NC524 _NC525 _NC526 _NC527 sky130_fd_sc_hd__a21oi_1
X132 105 27 104 _NC528 _NC529 _NC530 _NC531 sky130_fd_sc_hd__nor2_1
X133 106 mask_5_ 95 result_5_ _NC532 _NC533 _NC534 _NC535 sky130_fd_sc_hd__a21oi_1
X134 107 27 106 _NC536 _NC537 _NC538 _NC539 sky130_fd_sc_hd__nor2_1
X135 108 mask_6_ 95 result_6_ _NC540 _NC541 _NC542 _NC543 sky130_fd_sc_hd__a21oi_1
X136 109 27 108 _NC544 _NC545 _NC546 _NC547 sky130_fd_sc_hd__nor2_1
X137 110 mask_7_ 95 result_7_ _NC548 _NC549 _NC550 _NC551 sky130_fd_sc_hd__a21oi_1
X138 111 27 110 _NC552 _NC553 _NC554 _NC555 sky130_fd_sc_hd__nor2_1
X139 clkc clk en_co_clk _NC556 _NC557 _NC558 _NC559 sky130_fd_sc_hd__lpflow_isobufsrc_1
X140 result_0_ clk 97 rstn _NC560 _NC561 _NC562 _NC563 sky130_fd_sc_hd__dfrtp_1
X141 result_1_ clk 99 rstn _NC564 _NC565 _NC566 _NC567 sky130_fd_sc_hd__dfrtp_1
X142 result_2_ clk 101 rstn _NC568 _NC569 _NC570 _NC571 sky130_fd_sc_hd__dfrtp_1
X143 result_3_ clk 103 rstn _NC572 _NC573 _NC574 _NC575 sky130_fd_sc_hd__dfrtp_1
X144 result_4_ clk 105 rstn _NC576 _NC577 _NC578 _NC579 sky130_fd_sc_hd__dfrtp_1
X145 result_5_ clk 107 rstn _NC580 _NC581 _NC582 _NC583 sky130_fd_sc_hd__dfrtp_1
X146 result_6_ clk 109 rstn _NC584 _NC585 _NC586 _NC587 sky130_fd_sc_hd__dfrtp_1
X147 result_7_ clk 111 rstn _NC588 _NC589 _NC590 _NC591 sky130_fd_sc_hd__dfrtp_1
X148 calibrate clk 94 rstn _NC592 _NC593 _NC594 _NC595 sky130_fd_sc_hd__dfrtp_1
X149 state_0_ clk 87 rstn _NC596 _NC597 _NC598 _NC599 sky130_fd_sc_hd__dfrtp_1
X150 state_1_ clk 89 rstn _NC600 _NC601 _NC602 _NC603 sky130_fd_sc_hd__dfrtp_1
X151 state_2_ clk 91 rstn _NC604 _NC605 _NC606 _NC607 sky130_fd_sc_hd__dfrtp_1
X152 mask_0_ clk 74 rstn _NC608 _NC609 _NC610 _NC611 sky130_fd_sc_hd__dfrtp_1
X153 mask_1_ clk 75 rstn _NC612 _NC613 _NC614 _NC615 sky130_fd_sc_hd__dfrtp_1
X154 mask_2_ clk 76 rstn _NC616 _NC617 _NC618 _NC619 sky130_fd_sc_hd__dfrtp_1
X155 mask_3_ clk 77 rstn _NC620 _NC621 _NC622 _NC623 sky130_fd_sc_hd__dfrtp_1
X156 mask_4_ clk 78 rstn _NC624 _NC625 _NC626 _NC627 sky130_fd_sc_hd__dfrtp_1
X157 mask_5_ clk 79 rstn _NC628 _NC629 _NC630 _NC631 sky130_fd_sc_hd__dfrtp_1
X158 mask_6_ clk 80 rstn _NC632 _NC633 _NC634 _NC635 sky130_fd_sc_hd__dfrtp_1
X159 mask_7_ clk 82 rstn _NC636 _NC637 _NC638 _NC639 sky130_fd_sc_hd__dfrtp_1
X160 trim_mask_0_ clk 68 rstn _NC640 _NC641 _NC642 _NC643 sky130_fd_sc_hd__dfrtp_1
X161 trim_mask_1_ clk 69 rstn _NC644 _NC645 _NC646 _NC647 sky130_fd_sc_hd__dfrtp_1
X162 trim_mask_2_ clk 70 rstn _NC648 _NC649 _NC650 _NC651 sky130_fd_sc_hd__dfrtp_1
X163 trim_mask_3_ clk 71 rstn _NC652 _NC653 _NC654 _NC655 sky130_fd_sc_hd__dfrtp_1
X164 trim_mask_4_ clk 72 rstn _NC656 _NC657 _NC658 _NC659 sky130_fd_sc_hd__dfrtp_1
X165 trim_val_0_ clk 58 rstn _NC660 _NC661 _NC662 _NC663 sky130_fd_sc_hd__dfrtp_1
X166 trim_val_1_ clk 60 rstn _NC664 _NC665 _NC666 _NC667 sky130_fd_sc_hd__dfrtp_1
X167 trim_val_2_ clk 62 rstn _NC668 _NC669 _NC670 _NC671 sky130_fd_sc_hd__dfrtp_1
X168 trim_val_3_ clk 64 rstn _NC672 _NC673 _NC674 _NC675 sky130_fd_sc_hd__dfrtp_1
X169 trim_val_4_ clk 66 rstn _NC676 _NC677 _NC678 _NC679 sky130_fd_sc_hd__dfrtp_1
X170 en_co_clk clk 51 rstn _NC680 _NC681 _NC682 _NC683 sky130_fd_sc_hd__dfrtp_1
X171 cal_count_0_ clk 29 rstn _NC684 _NC685 _NC686 _NC687 sky130_fd_sc_hd__dfstp_2
X172 cal_count_1_ clk 35 rstn _NC688 _NC689 _NC690 _NC691 sky130_fd_sc_hd__dfstp_2
X173 cal_count_2_ clk 39 rstn _NC692 _NC693 _NC694 _NC695 sky130_fd_sc_hd__dfstp_2
X174 cal_count_3_ clk 43 rstn _NC696 _NC697 _NC698 _NC699 sky130_fd_sc_hd__dfrtp_1
X175 cal_itt_0_ clk 14 rstn _NC700 _NC701 _NC702 _NC703 sky130_fd_sc_hd__dfrtp_1
X176 cal_itt_1_ clk 18 rstn _NC704 _NC705 _NC706 _NC707 sky130_fd_sc_hd__dfrtp_1
X177 cal_itt_2_ clk 21 rstn _NC708 _NC709 _NC710 _NC711 sky130_fd_sc_hd__dfrtp_1
X178 cal_itt_3_ clk 23 rstn _NC712 _NC713 _NC714 _NC715 sky130_fd_sc_hd__dfrtp_1
V0 co_clk Vss DC 0
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
