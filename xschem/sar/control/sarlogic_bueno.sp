* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT sar_logic clk rstn en comp cal valid result.0 result.1 result.2 result.3 result.4 result.5 result.6 result.7 sample ctlp.0 ctlp.1 ctlp.2 ctlp.3 ctlp.4 ctlp.5 ctlp.6 ctlp.7 ctln.0 ctln.1 ctln.2 ctln.3 ctln.4 ctln.5 ctln.6 ctln.7 trim.0 trim.1 trim.2 trim.3 trim.4 trimb.0 trimb.1 trimb.2 trimb.3 trimb.4 clkc
X0 state.4 1 sky130_fd_sc_hd__clkinv_1
X1 state.5 2 sky130_fd_sc_hd__clkinv_1
X2 state.2 3 sky130_fd_sc_hd__clkinv_1
X3 state.2 4 calibrate sky130_fd_sc_hd__nand2b_1
X4 2 mask.0 5 sky130_fd_sc_hd__nor2_1
X5 6 2 mask.0 4 sky130_fd_sc_hd__o21ai_0
X6 cal_itt.0 cal_itt.1 7 sky130_fd_sc_hd__nand2_1
X7 cal_itt.0 cal_itt.1 8 cal_itt.2 sky130_fd_sc_hd__nand3_1
X8 cal_itt.0 cal_itt.1 9 cal_itt.2 cal_itt.3 sky130_fd_sc_hd__and4b_1
X9 10 cal_itt.3 8 state.4 sky130_fd_sc_hd__o21ai_0
X10 11 trim_mask.0 9 1 sky130_fd_sc_hd__a21oi_1
X11 12 state.2 calibrate 11 sky130_fd_sc_hd__a21o_1
X12 state.5 mask.0 13 sky130_fd_sc_hd__nand2_1
X13 cal_itt.3 1 14 8 sky130_fd_sc_hd__nor3_1
X14 state.4 9 15 sky130_fd_sc_hd__nand2_1
X15 trim_mask.0 14 16 sky130_fd_sc_hd__nand2_1
X16 13 16 17 sky130_fd_sc_hd__nand2_1
X17 state.3 18 en sky130_fd_sc_hd__lpflow_isobufsrc_1
X18 state.1 state.0 18 19 sky130_fd_sc_hd__or3_1
X19 1 3 20 sky130_fd_sc_hd__nand2_1
X20 trim_mask.0 trim_val.0 21 sky130_fd_sc_hd__nor2_1
X21 21 22 sky130_fd_sc_hd__clkinv_1
X22 trim_val.1 trim_mask.1 23 sky130_fd_sc_hd__nor2_1
X23 23 24 sky130_fd_sc_hd__clkinv_1
X24 trim_val.2 trim_mask.2 25 sky130_fd_sc_hd__nor2_1
X25 25 26 sky130_fd_sc_hd__clkinv_1
X26 trim_val.3 trim_mask.3 27 sky130_fd_sc_hd__nor2_1
X27 27 28 sky130_fd_sc_hd__clkinv_1
X28 trim_val.4 trim_mask.4 29 sky130_fd_sc_hd__nor2_1
X29 29 30 sky130_fd_sc_hd__clkinv_1
X30 mask.0 result.0 31 sky130_fd_sc_hd__nor2_1
X31 31 32 sky130_fd_sc_hd__clkinv_1
X32 mask.1 result.1 33 sky130_fd_sc_hd__nor2_1
X33 33 34 sky130_fd_sc_hd__clkinv_1
X34 mask.2 result.2 35 sky130_fd_sc_hd__nor2_1
X35 35 36 sky130_fd_sc_hd__clkinv_1
X36 mask.3 result.3 37 sky130_fd_sc_hd__nor2_1
X37 37 38 sky130_fd_sc_hd__clkinv_1
X38 mask.4 result.4 39 sky130_fd_sc_hd__nor2_1
X39 39 40 sky130_fd_sc_hd__clkinv_1
X40 mask.5 result.5 41 sky130_fd_sc_hd__nor2_1
X41 41 42 sky130_fd_sc_hd__clkinv_1
X42 mask.6 result.6 43 sky130_fd_sc_hd__nor2_1
X43 43 44 sky130_fd_sc_hd__clkinv_1
X44 mask.7 result.7 45 sky130_fd_sc_hd__nor2_1
X45 45 46 sky130_fd_sc_hd__clkinv_1
X46 state.4 state.3 47 sky130_fd_sc_hd__nor2_1
X47 18 48 47 sky130_fd_sc_hd__lpflow_inputiso1p_1
X48 cal_itt.0 49 48 state.4 sky130_fd_sc_hd__mux2i_1
X49 16 49 50 sky130_fd_sc_hd__nand2_1
X50 cal_itt.0 cal_itt.1 51 sky130_fd_sc_hd__nor2_1
X51 52 state.4 7 48 cal_itt.1 sky130_fd_sc_hd__a22oi_1
X52 53 51 52 16 sky130_fd_sc_hd__o21ai_0
X53 54 state.4 8 48 sky130_fd_sc_hd__a21oi_1
X54 55 state.4 cal_itt.0 cal_itt.2 cal_itt.1 sky130_fd_sc_hd__a31oi_1
X55 56 54 55 16 sky130_fd_sc_hd__o21ai_0
X56 cal_itt.3 57 54 sky130_fd_sc_hd__lpflow_isobufsrc_1
X57 state.4 58 state.3 sky130_fd_sc_hd__nand2b_1
X58 state.3 en 59 sky130_fd_sc_hd__nand2_1
X59 59 60 sky130_fd_sc_hd__clkinv_1
X60 61 cal_count.0 60 58 sky130_fd_sc_hd__o21ai_0
X61 62 1 cal_count.0 15 61 sky130_fd_sc_hd__o211ai_1
X62 cal_count.0 cal_count.1 63 sky130_fd_sc_hd__nand2_1
X63 cal_count.0 64 cal_count.1 comp sky130_fd_sc_hd__nand3b_1
X64 cal_count.0 cal_count.1 65 sky130_fd_sc_hd__nor2_1
X65 66 comp 63 65 sky130_fd_sc_hd__a21oi_1
X66 cal_count.0 cal_count.1 67 comp sky130_fd_sc_hd__or3b_1
X67 68 comp 65 66 9 64 sky130_fd_sc_hd__a221oi_1
X68 69 cal_count.1 60 58 sky130_fd_sc_hd__o21ai_0
X69 70 1 68 69 sky130_fd_sc_hd__o21ai_0
X70 71 64 67 cal_count.2 sky130_fd_sc_hd__a21oi_1
X71 cal_count.2 64 67 72 sky130_fd_sc_hd__and3_1
X72 73 cal_count.2 60 58 sky130_fd_sc_hd__o21ai_0
X73 9 71 74 72 sky130_fd_sc_hd__nor3_1
X74 75 1 74 73 sky130_fd_sc_hd__o21ai_0
X75 cal_count.3 48 76 sky130_fd_sc_hd__nand2_1
X76 cal_count.2 77 64 67 sky130_fd_sc_hd__mux2i_1
X77 cal_count.3 77 78 sky130_fd_sc_hd__xnor2_1
X78 79 10 78 76 sky130_fd_sc_hd__o21ai_0
X79 80 state.3 5 60 en_co_clk 11 sky130_fd_sc_hd__o32ai_1
X80 en_co_clk 47 81 sky130_fd_sc_hd__nand2_1
X81 82 state.5 81 80 sky130_fd_sc_hd__o21ai_0
X82 83 state.0 state.2 4 1 sky130_fd_sc_hd__o211ai_1
X83 84 trim_mask.0 cal_count.3 83 trim_val.0 14 sky130_fd_sc_hd__a32o_1
X84 85 cal_count.3 trim_mask.1 83 trim_val.1 14 sky130_fd_sc_hd__a32o_1
X85 86 cal_count.3 trim_mask.2 83 trim_val.2 14 sky130_fd_sc_hd__a32o_1
X86 87 cal_count.3 trim_mask.3 83 trim_val.3 14 sky130_fd_sc_hd__a32o_1
X87 cal_count.3 trim_mask.4 88 14 sky130_fd_sc_hd__nand3_1
X88 89 trim_val.4 83 state.0 sky130_fd_sc_hd__a21oi_1
X89 88 89 90 sky130_fd_sc_hd__nand2_1
X90 4 10 91 20 sky130_fd_sc_hd__nand3_1
X91 92 trim_mask.1 14 91 trim_mask.0 sky130_fd_sc_hd__a22o_1
X92 93 trim_mask.2 14 91 trim_mask.1 sky130_fd_sc_hd__a22o_1
X93 94 trim_mask.3 14 91 trim_mask.2 sky130_fd_sc_hd__a22o_1
X94 95 trim_mask.4 14 91 trim_mask.3 sky130_fd_sc_hd__a22o_1
X95 96 state.2 calibrate trim_mask.4 sky130_fd_sc_hd__a21oi_1
X96 97 3 14 96 sky130_fd_sc_hd__a21oi_1
X97 98 2 state.3 59 sky130_fd_sc_hd__o21a_1
X98 99 state.5 mask.1 98 mask.0 sky130_fd_sc_hd__a22o_1
X99 100 state.5 mask.2 98 mask.1 sky130_fd_sc_hd__a22o_1
X100 101 state.5 mask.3 98 mask.2 sky130_fd_sc_hd__a22o_1
X101 102 state.5 mask.4 98 mask.3 sky130_fd_sc_hd__a22o_1
X102 103 state.5 mask.5 98 mask.4 sky130_fd_sc_hd__a22o_1
X103 104 state.5 mask.6 98 mask.5 sky130_fd_sc_hd__a22o_1
X104 105 state.5 mask.7 98 mask.6 sky130_fd_sc_hd__a22o_1
X105 106 2 state.3 mask.7 sky130_fd_sc_hd__o21ai_0
X106 59 106 107 sky130_fd_sc_hd__nand2_1
X107 cal 60 108 sky130_fd_sc_hd__nand2_1
X108 109 11 48 calibrate sky130_fd_sc_hd__o21ai_0
X109 108 109 110 sky130_fd_sc_hd__nand2_1
X110 state.5 59 111 sky130_fd_sc_hd__nor2_1
X111 112 state.5 comp result.0 mask.0 sky130_fd_sc_hd__a31oi_1
X112 111 112 113 sky130_fd_sc_hd__nor2_1
X113 114 state.5 comp result.1 mask.1 sky130_fd_sc_hd__a31oi_1
X114 111 114 115 sky130_fd_sc_hd__nor2_1
X115 116 state.5 comp result.2 mask.2 sky130_fd_sc_hd__a31oi_1
X116 111 116 117 sky130_fd_sc_hd__nor2_1
X117 118 state.5 comp result.3 mask.3 sky130_fd_sc_hd__a31oi_1
X118 111 118 119 sky130_fd_sc_hd__nor2_1
X119 120 state.5 comp result.4 mask.4 sky130_fd_sc_hd__a31oi_1
X120 111 120 121 sky130_fd_sc_hd__nor2_1
X121 122 state.5 comp result.5 mask.5 sky130_fd_sc_hd__a31oi_1
X122 111 122 123 sky130_fd_sc_hd__nor2_1
X123 124 state.5 comp result.6 mask.6 sky130_fd_sc_hd__a31oi_1
X124 111 124 125 sky130_fd_sc_hd__nor2_1
X125 126 state.5 comp result.7 mask.7 sky130_fd_sc_hd__a31oi_1
X126 111 126 127 sky130_fd_sc_hd__nor2_1
X127 en_co_clk 128 clk sky130_fd_sc_hd__lpflow_isobufsrc_1
X128 clk cal_itt.1 53 rstn sky130_fd_sc_hd__dfrtp_1
X129 clk cal_itt.2 56 rstn sky130_fd_sc_hd__dfrtp_1
X130 clk cal_itt.3 57 rstn sky130_fd_sc_hd__dfrtp_1
X131 clk state.0 Vss rstn sky130_fd_sc_hd__dfstp_2
X132 clk state.1 17 rstn sky130_fd_sc_hd__dfrtp_1
X133 clk state.2 60 rstn sky130_fd_sc_hd__dfrtp_1
X134 clk state.3 19 rstn sky130_fd_sc_hd__dfrtp_1
X135 clk state.4 12 rstn sky130_fd_sc_hd__dfrtp_1
X136 clk state.5 6 rstn sky130_fd_sc_hd__dfrtp_1
X137 clk result.0 113 rstn sky130_fd_sc_hd__dfrtp_1
X138 clk result.1 115 rstn sky130_fd_sc_hd__dfrtp_1
X139 clk result.2 117 rstn sky130_fd_sc_hd__dfrtp_1
X140 clk result.3 119 rstn sky130_fd_sc_hd__dfrtp_1
X141 clk result.4 121 rstn sky130_fd_sc_hd__dfrtp_1
X142 clk result.5 123 rstn sky130_fd_sc_hd__dfrtp_1
X143 clk result.6 125 rstn sky130_fd_sc_hd__dfrtp_1
X144 clk result.7 127 rstn sky130_fd_sc_hd__dfrtp_1
X145 clk calibrate 110 rstn sky130_fd_sc_hd__dfrtp_1
X146 clk mask.0 99 rstn sky130_fd_sc_hd__dfrtp_1
X147 clk mask.1 100 rstn sky130_fd_sc_hd__dfrtp_1
X148 clk mask.2 101 rstn sky130_fd_sc_hd__dfrtp_1
X149 clk mask.3 102 rstn sky130_fd_sc_hd__dfrtp_1
X150 clk mask.4 103 rstn sky130_fd_sc_hd__dfrtp_1
X151 clk mask.5 104 rstn sky130_fd_sc_hd__dfrtp_1
X152 clk mask.6 105 rstn sky130_fd_sc_hd__dfrtp_1
X153 clk mask.7 107 rstn sky130_fd_sc_hd__dfrtp_1
X154 clk trim_mask.0 92 rstn sky130_fd_sc_hd__dfrtp_1
X155 clk trim_mask.1 93 rstn sky130_fd_sc_hd__dfrtp_1
X156 clk trim_mask.2 94 rstn sky130_fd_sc_hd__dfrtp_1
X157 clk trim_mask.3 95 rstn sky130_fd_sc_hd__dfrtp_1
X158 clk trim_mask.4 97 rstn sky130_fd_sc_hd__dfrtp_1
X159 clk trim_val.0 84 rstn sky130_fd_sc_hd__dfrtp_1
X160 clk trim_val.1 85 rstn sky130_fd_sc_hd__dfrtp_1
X161 clk trim_val.2 86 rstn sky130_fd_sc_hd__dfrtp_1
X162 clk trim_val.3 87 rstn sky130_fd_sc_hd__dfrtp_1
X163 clk trim_val.4 90 rstn sky130_fd_sc_hd__dfrtp_1
X164 clk en_co_clk 82 rstn sky130_fd_sc_hd__dfrtp_1
X165 clk cal_count.0 62 rstn sky130_fd_sc_hd__dfstp_2
X166 clk cal_count.1 70 rstn sky130_fd_sc_hd__dfstp_2
X167 clk cal_count.2 75 rstn sky130_fd_sc_hd__dfstp_2
X168 clk cal_count.3 79 rstn sky130_fd_sc_hd__dfrtp_1
X169 clk cal_itt.0 50 rstn sky130_fd_sc_hd__dfrtp_1
V0 129.0 Vss DC 0
V1 129.2 130 DC 0
V2 131.2 Vdd DC 0
V3 131.3 Vdd DC 0
V4 131.4 Vdd DC 0
V5 131.5 Vdd DC 0
V6 131.6 Vdd DC 0
V7 131.7 Vdd DC 0
V8 131.8 Vdd DC 0
V9 131.9 Vdd DC 0
V10 131.10 Vdd DC 0
V11 131.11 Vdd DC 0
V12 131.12 Vdd DC 0
V13 131.13 Vdd DC 0
V14 131.14 Vdd DC 0
V15 131.15 Vdd DC 0
V16 132.1 Vdd DC 0
V17 132.2 Vdd DC 0
V18 132.3 Vdd DC 0
V19 132.4 Vdd DC 0
V20 132.5 Vdd DC 0
V21 132.6 Vdd DC 0
V22 132.7 Vdd DC 0
V23 133.0 trim_mask.0 DC 0
V24 134.0 135.0 DC 0
V25 134.3 cal_itt.3 DC 0
V26 136.1 133.1 DC 0
V27 137.7 Vss DC 0
V28 138.7 137.15 DC 0
V29 139.0 140.0 DC 0
V30 141.10 Vss DC 0
V31 141.11 Vss DC 0
V32 141.12 Vss DC 0
V33 141.13 Vss DC 0
V34 141.14 state.0 DC 0
V35 142.0 143 DC 0
V36 142.1 144 DC 0
V37 142.2 145 DC 0
V38 142.3 146 DC 0
V39 147.0 140.0 DC 0
V40 148.0 cal_count.0 DC 0
V41 148.1 131.0 DC 0
V42 149.0 cal_itt.0 DC 0
V43 150.0 cal_count.0 DC 0
V44 150.1 131.0 DC 0
V45 150.2 148.2 DC 0
V46 150.3 150.31 DC 0
V47 150.4 150.31 DC 0
V48 150.5 150.31 DC 0
V49 150.6 150.31 DC 0
V50 150.7 150.31 DC 0
V51 150.8 150.31 DC 0
V52 150.9 150.31 DC 0
V53 150.10 150.31 DC 0
V54 150.11 150.31 DC 0
V55 150.12 150.31 DC 0
V56 150.13 150.31 DC 0
V57 150.14 150.31 DC 0
V58 150.15 150.31 DC 0
V59 150.16 150.31 DC 0
V60 150.17 150.31 DC 0
V61 150.18 150.31 DC 0
V62 150.19 150.31 DC 0
V63 150.20 150.31 DC 0
V64 150.21 150.31 DC 0
V65 150.22 150.31 DC 0
V66 150.23 150.31 DC 0
V67 150.24 150.31 DC 0
V68 150.25 150.31 DC 0
V69 150.26 150.31 DC 0
V70 150.27 150.31 DC 0
V71 150.28 150.31 DC 0
V72 150.29 150.31 DC 0
V73 150.30 150.31 DC 0
V74 151.0 cal_count.0 DC 0
V75 151.1 cal_count.1 DC 0
V76 151.2 cal_count.2 DC 0
V77 151.4 Vdd DC 0
V78 151.5 Vdd DC 0
V79 151.6 Vdd DC 0
V80 151.7 Vdd DC 0
V81 151.8 Vdd DC 0
V82 151.9 Vdd DC 0
V83 151.10 Vdd DC 0
V84 151.11 Vdd DC 0
V85 151.12 Vdd DC 0
V86 151.13 Vdd DC 0
V87 151.14 Vdd DC 0
V88 151.15 Vdd DC 0
V89 151.16 Vdd DC 0
V90 151.17 Vdd DC 0
V91 151.18 Vdd DC 0
V92 151.19 Vdd DC 0
V93 151.20 Vdd DC 0
V94 151.21 Vdd DC 0
V95 151.22 Vdd DC 0
V96 151.23 Vdd DC 0
V97 151.24 Vdd DC 0
V98 151.25 Vdd DC 0
V99 151.26 Vdd DC 0
V100 151.27 Vdd DC 0
V101 151.28 Vdd DC 0
V102 151.29 Vdd DC 0
V103 151.30 Vdd DC 0
V104 151.31 Vdd DC 0
V105 152.0 cal_count.0 DC 0
V106 153.0 cal_count.0 DC 0
V107 153.3 151.3 DC 0
V108 valid state.1 DC 0
V109 154 cal_itt.3 DC 0
V110 129.5 6 DC 0
V111 129.4 12 DC 0
V112 129.1 17 DC 0
V113 155 state.1 DC 0
V114 156 state.0 DC 0
V115 129.3 19 DC 0
V116 157 state.4 DC 0
V117 158 state.5 DC 0
V118 159 state.3 DC 0
V119 160 state.2 DC 0
V120 sample 20 DC 0
V121 161 cal_itt.0 DC 0
V122 162 trim_mask.0 DC 0
V123 163 cal_itt.1 DC 0
V124 164 cal_itt.2 DC 0
V125 165 comp DC 0
V126 166 en DC 0
V127 167 cal_count.0 DC 0
V128 168 cal_count.1 DC 0
V129 169 cal_count.2 DC 0
V130 170 cal_count.3 DC 0
V131 171 en_co_clk DC 0
V132 172 mask.0 DC 0
V133 trim.0 22 DC 0
V134 173 trim_val.0 DC 0
V135 trim.1 24 DC 0
V136 174 trim_val.1 DC 0
V137 trim.2 26 DC 0
V138 175 trim_val.2 DC 0
V139 trim.3 28 DC 0
V140 176 trim_val.3 DC 0
V141 trim.4 30 DC 0
V142 177 trim_val.4 DC 0
V143 178 calibrate DC 0
V144 179 trim_mask.1 DC 0
V145 180 trim_mask.2 DC 0
V146 181 trim_mask.3 DC 0
V147 182 trim_mask.4 DC 0
V148 183 mask.1 DC 0
V149 184 mask.2 DC 0
V150 185 mask.3 DC 0
V151 186 mask.4 DC 0
V152 187 mask.5 DC 0
V153 188 mask.6 DC 0
V154 189 mask.7 DC 0
V155 190 cal DC 0
V156 191 result.0 DC 0
V157 ctlp.0 32 DC 0
V158 192 result.1 DC 0
V159 ctlp.1 34 DC 0
V160 193 result.2 DC 0
V161 ctlp.2 36 DC 0
V162 194 result.3 DC 0
V163 ctlp.3 38 DC 0
V164 195 result.4 DC 0
V165 ctlp.4 40 DC 0
V166 196 result.5 DC 0
V167 ctlp.5 42 DC 0
V168 197 result.6 DC 0
V169 ctlp.6 44 DC 0
V170 198 result.7 DC 0
V171 ctlp.7 46 DC 0
V172 199.0 50 DC 0
V173 199.1 53 DC 0
V174 199.2 56 DC 0
V175 199.3 57 DC 0
V176 200.0 62 DC 0
V177 200.1 70 DC 0
V178 200.2 75 DC 0
V179 200.3 79 DC 0
V180 201 82 DC 0
V181 202.0 84 DC 0
V182 202.1 85 DC 0
V183 202.2 86 DC 0
V184 202.3 87 DC 0
V185 202.4 90 DC 0
V186 203.0 92 DC 0
V187 203.1 93 DC 0
V188 203.2 94 DC 0
V189 203.3 95 DC 0
V190 203.4 97 DC 0
V191 204.0 99 DC 0
V192 204.1 100 DC 0
V193 204.2 101 DC 0
V194 204.3 102 DC 0
V195 204.4 103 DC 0
V196 204.5 104 DC 0
V197 204.6 105 DC 0
V198 204.7 107 DC 0
V199 205 110 DC 0
V200 206.0 113 DC 0
V201 206.1 115 DC 0
V202 206.2 117 DC 0
V203 206.3 119 DC 0
V204 206.4 121 DC 0
V205 206.5 123 DC 0
V206 206.6 125 DC 0
V207 206.7 127 DC 0
V208 207 clk DC 0
V209 trimb.0 21 DC 0
V210 trimb.1 23 DC 0
V211 trimb.2 25 DC 0
V212 trimb.3 27 DC 0
V213 trimb.4 29 DC 0
V214 ctln.0 31 DC 0
V215 ctln.1 33 DC 0
V216 ctln.2 35 DC 0
V217 ctln.3 37 DC 0
V218 ctln.4 39 DC 0
V219 ctln.5 41 DC 0
V220 ctln.6 43 DC 0
V221 ctln.7 45 DC 0
V222 clkc 128 DC 0
V223 130 60 DC 0
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
