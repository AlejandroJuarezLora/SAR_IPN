* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT sar_logic clk rstn en comp cal valid result_0_ result_1_ result_2_ result_3_ result_4_ result_5_ result_6_ result_7_ sample ctlp_0_ ctlp_1_ ctlp_2_ ctlp_3_ ctlp_4_ ctlp_5_ ctlp_6_ ctlp_7_ ctln_0_ ctln_1_ ctln_2_ ctln_3_ ctln_4_ ctln_5_ ctln_6_ ctln_7_ trim_0_ trim_1_ trim_2_ trim_3_ trim_4_ trimb_0_ trimb_1_ trimb_2_ trimb_3_ trimb_4_ clkc
X0 mask_4_ result_4_ ctln_4_ sky130_fd_sc_hd__nor2_1
X1 ctln_4_ ctlp_4_ sky130_fd_sc_hd__clkinv_1
X2 mask_5_ result_5_ ctln_5_ sky130_fd_sc_hd__nor2_1
X3 ctln_5_ ctlp_5_ sky130_fd_sc_hd__clkinv_1
X4 mask_6_ result_6_ ctln_6_ sky130_fd_sc_hd__nor2_1
X5 ctln_6_ ctlp_6_ sky130_fd_sc_hd__clkinv_1
X6 mask_7_ result_7_ ctln_7_ sky130_fd_sc_hd__nor2_1
X7 ctln_7_ ctlp_7_ sky130_fd_sc_hd__clkinv_1
X8 cal_itt_0_ cal_itt_1_ 1 sky130_fd_sc_hd__nand2_1
X9 cal_itt_0_ cal_itt_1_ 2 cal_itt_2_ cal_itt_3_ sky130_fd_sc_hd__and4b_1
X10 cal_itt_0_ 3 cal_itt_1_ cal_itt_2_ cal_itt_3_ sky130_fd_sc_hd__nand4b_1
X11 trim_mask_0_ 2 4 sky130_fd_sc_hd__nand2_1
X12 5 cal_itt_0_ 4 6 sky130_fd_sc_hd__a21oi_1
X13 7 state_2_ en 8 sky130_fd_sc_hd__o21ai_0
X14 7 9 sky130_fd_sc_hd__clkinv_1
X15 10 cal_itt_0_ 7 5 sky130_fd_sc_hd__a21o_1
X16 cal_itt_0_ cal_itt_1_ 11 sky130_fd_sc_hd__nor2_1
X17 cal_itt_1_ 7 12 sky130_fd_sc_hd__nand2_1
X18 13 trim_mask_0_ 2 1 sky130_fd_sc_hd__a21oi_1
X19 14 6 11 12 13 sky130_fd_sc_hd__o31ai_1
X20 cal_itt_2_ 1 15 sky130_fd_sc_hd__xor2_1
X21 16 4 15 6 sky130_fd_sc_hd__a21oi_1
X22 17 cal_itt_2_ 7 16 sky130_fd_sc_hd__a21o_1
X23 18 cal_itt_0_ cal_itt_1_ 6 cal_itt_2_ sky130_fd_sc_hd__a31oi_1
X24 19 7 18 cal_itt_3_ sky130_fd_sc_hd__o21a_1
X25 state_2_ 8 20 3 sky130_fd_sc_hd__nand3_1
X26 state_0_ 21 state_2_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X27 state_2_ state_1_ 22 state_0_ sky130_fd_sc_hd__nor3b_1
X28 en 22 23 sky130_fd_sc_hd__and2_0
X29 24 cal_count_0_ 20 23 sky130_fd_sc_hd__a21oi_1
X30 25 cal_count_0_ 6 24 sky130_fd_sc_hd__o21ai_0
X31 26 cal_count_0_ cal_count_1_ comp sky130_fd_sc_hd__a21boi_0
X32 cal_count_0_ cal_count_1_ 27 sky130_fd_sc_hd__nor2_1
X33 cal_count_0_ cal_count_1_ 28 comp sky130_fd_sc_hd__and3b_1
X34 26 27 29 28 sky130_fd_sc_hd__nor3_1
X35 cal_count_0_ cal_count_1_ 30 comp sky130_fd_sc_hd__nor3b_1
X36 31 20 29 9 cal_count_1_ 30 sky130_fd_sc_hd__o32a_1
X37 28 30 32 sky130_fd_sc_hd__nor2_1
X38 33 cal_count_2_ 32 20 sky130_fd_sc_hd__o21ba_1
X39 34 20 32 cal_count_2_ sky130_fd_sc_hd__o21ai_0
X40 35 7 33 34 sky130_fd_sc_hd__o21ai_0
X41 cal_count_3_ 7 36 sky130_fd_sc_hd__nand2_1
X42 cal_count_2_ 37 28 30 sky130_fd_sc_hd__mux2i_1
X43 cal_count_3_ 37 38 sky130_fd_sc_hd__xor2_1
X44 39 20 38 36 sky130_fd_sc_hd__o21ai_0
X45 en_co_clk 23 40 sky130_fd_sc_hd__nor2_1
X46 41 trim_mask_0_ 2 6 sky130_fd_sc_hd__a21oi_1
X47 8 21 42 sky130_fd_sc_hd__nor2_1
X48 en_co_clk 42 43 sky130_fd_sc_hd__nand2_1
X49 state_1_ state_0_ 44 state_2_ sky130_fd_sc_hd__and3b_1
X50 44 45 mask_0_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X51 22 41 46 45 sky130_fd_sc_hd__nor3_1
X52 47 43 46 40 sky130_fd_sc_hd__a21oi_1
X53 6 3 48 sky130_fd_sc_hd__nor2_1
X54 state_0_ state_2_ 49 state_1_ sky130_fd_sc_hd__nor3_1
X55 state_1_ calibrate 50 51 sky130_fd_sc_hd__nand3_1
X56 50 52 49 sky130_fd_sc_hd__nand2b_1
X57 53 trim_mask_0_ cal_count_3_ trim_val_0_ 48 sky130_fd_sc_hd__a31oi_1
X58 52 53 54 sky130_fd_sc_hd__nor2_1
X59 55 cal_count_3_ 48 trim_val_1_ sky130_fd_sc_hd__a21oi_1
X60 trimb_1_ 52 56 55 sky130_fd_sc_hd__nor3_1
X61 57 cal_count_3_ 48 trim_val_2_ sky130_fd_sc_hd__a21oi_1
X62 trimb_2_ 52 58 57 sky130_fd_sc_hd__nor3_1
X63 59 cal_count_3_ 48 trim_val_3_ sky130_fd_sc_hd__a21oi_1
X64 trimb_3_ 52 60 59 sky130_fd_sc_hd__nor3_1
X65 cal_count_3_ trim_mask_4_ 61 48 sky130_fd_sc_hd__nand3_1
X66 62 trim_val_4_ 50 49 sky130_fd_sc_hd__a21oi_1
X67 61 62 63 sky130_fd_sc_hd__nand2_1
X68 64 6 50 20 sky130_fd_sc_hd__a21bo_1
X69 65 trim_mask_1_ 48 64 trim_mask_0_ sky130_fd_sc_hd__a22o_1
X70 66 trim_mask_2_ 48 64 trim_mask_1_ sky130_fd_sc_hd__a22o_1
X71 67 trim_mask_3_ 48 64 trim_mask_2_ sky130_fd_sc_hd__a22o_1
X72 68 trim_mask_4_ 48 64 trim_mask_3_ sky130_fd_sc_hd__a22o_1
X73 69 6 3 trim_mask_4_ sky130_fd_sc_hd__o21ai_0
X74 50 69 70 sky130_fd_sc_hd__nand2_1
X75 71 state_1_ en 21 sky130_fd_sc_hd__o21ai_0
X76 72 mask_1_ 44 71 mask_0_ sky130_fd_sc_hd__a22o_1
X77 73 mask_2_ 44 71 mask_1_ sky130_fd_sc_hd__a22o_1
X78 74 mask_3_ 44 71 mask_2_ sky130_fd_sc_hd__a22o_1
X79 75 mask_4_ 44 71 mask_3_ sky130_fd_sc_hd__a22o_1
X80 76 mask_5_ 44 71 mask_4_ sky130_fd_sc_hd__a22o_1
X81 77 mask_6_ 44 71 mask_5_ sky130_fd_sc_hd__a22o_1
X82 78 mask_7_ 44 71 mask_6_ sky130_fd_sc_hd__a22o_1
X83 mask_7_ 23 79 sky130_fd_sc_hd__nor2_1
X84 44 79 80 sky130_fd_sc_hd__nor2_1
X85 81 state_2_ state_1_ state_0_ sky130_fd_sc_hd__a21oi_1
X86 state_2_ state_1_ 82 sky130_fd_sc_hd__nand2_1
X87 83 state_2_ state_1_ 41 sky130_fd_sc_hd__a21oi_1
X88 trim_mask_0_ 6 84 3 sky130_fd_sc_hd__nor3_1
X89 85 86 22 45 81 84 sky130_fd_sc_hd__a2111oi_0
X90 87 88 83 85 sky130_fd_sc_hd__o21ai_0
X91 23 45 89 sky130_fd_sc_hd__nor2_1
X92 90 calibrate 91 82 89 sky130_fd_sc_hd__o211ai_1
X93 mask_0_ 44 92 sky130_fd_sc_hd__nand2_1
X94 6 50 93 82 92 sky130_fd_sc_hd__nand4_1
X95 cal 23 94 sky130_fd_sc_hd__nand2_1
X96 95 7 41 calibrate sky130_fd_sc_hd__o21ai_0
X97 94 95 96 sky130_fd_sc_hd__nand2_1
X98 comp 44 97 sky130_fd_sc_hd__and2_0
X99 98 mask_0_ 97 result_0_ sky130_fd_sc_hd__a21oi_1
X100 23 98 99 sky130_fd_sc_hd__nor2_1
X101 100 mask_1_ 97 result_1_ sky130_fd_sc_hd__a21oi_1
X102 23 100 101 sky130_fd_sc_hd__nor2_1
X103 102 mask_2_ 97 result_2_ sky130_fd_sc_hd__a21oi_1
X104 23 102 103 sky130_fd_sc_hd__nor2_1
X105 104 mask_3_ 97 result_3_ sky130_fd_sc_hd__a21oi_1
X106 23 104 105 sky130_fd_sc_hd__nor2_1
X107 106 mask_4_ 97 result_4_ sky130_fd_sc_hd__a21oi_1
X108 23 106 107 sky130_fd_sc_hd__nor2_1
X109 108 mask_5_ 97 result_5_ sky130_fd_sc_hd__a21oi_1
X110 23 108 109 sky130_fd_sc_hd__nor2_1
X111 110 mask_6_ 97 result_6_ sky130_fd_sc_hd__a21oi_1
X112 23 110 111 sky130_fd_sc_hd__nor2_1
X113 112 mask_7_ 97 result_7_ sky130_fd_sc_hd__a21oi_1
X114 23 112 113 sky130_fd_sc_hd__nor2_1
X115 en_co_clk clkc clk sky130_fd_sc_hd__lpflow_isobufsrc_1
X116 state_0_ 88 sky130_fd_sc_hd__clkinv_1
X117 en 86 sky130_fd_sc_hd__clkinv_1
X118 state_0_ 8 state_1_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X119 state_2_ 6 state_0_ state_1_ sky130_fd_sc_hd__nand3b_1
X120 state_0_ state_2_ 51 sky130_fd_sc_hd__nor2_1
X121 state_1_ 51 91 sky130_fd_sc_hd__nand2_1
X122 6 91 sample sky130_fd_sc_hd__nand2_1
X123 state_0_ state_1_ valid state_2_ sky130_fd_sc_hd__nor3b_1
X124 trim_mask_0_ trim_val_0_ trimb_0_ sky130_fd_sc_hd__nor2_1
X125 trimb_0_ trim_0_ sky130_fd_sc_hd__clkinv_1
X126 trim_val_1_ trim_mask_1_ trimb_1_ sky130_fd_sc_hd__nor2_1
X127 trimb_1_ trim_1_ sky130_fd_sc_hd__clkinv_1
X128 trim_val_2_ trim_mask_2_ trimb_2_ sky130_fd_sc_hd__nor2_1
X129 trimb_2_ trim_2_ sky130_fd_sc_hd__clkinv_1
X130 trim_val_3_ trim_mask_3_ trimb_3_ sky130_fd_sc_hd__nor2_1
X131 trimb_3_ trim_3_ sky130_fd_sc_hd__clkinv_1
X132 trim_val_4_ trim_mask_4_ trimb_4_ sky130_fd_sc_hd__nor2_1
X133 trimb_4_ trim_4_ sky130_fd_sc_hd__clkinv_1
X134 mask_0_ result_0_ ctln_0_ sky130_fd_sc_hd__nor2_1
X135 ctln_0_ ctlp_0_ sky130_fd_sc_hd__clkinv_1
X136 mask_1_ result_1_ ctln_1_ sky130_fd_sc_hd__nor2_1
X137 ctln_1_ ctlp_1_ sky130_fd_sc_hd__clkinv_1
X138 mask_2_ result_2_ ctln_2_ sky130_fd_sc_hd__nor2_1
X139 ctln_2_ ctlp_2_ sky130_fd_sc_hd__clkinv_1
X140 mask_3_ result_3_ ctln_3_ sky130_fd_sc_hd__nor2_1
X141 ctln_3_ ctlp_3_ sky130_fd_sc_hd__clkinv_1
X142 clk result_0_ 99 rstn sky130_fd_sc_hd__dfrtp_1
X143 clk result_1_ 101 rstn sky130_fd_sc_hd__dfrtp_1
X144 clk result_2_ 103 rstn sky130_fd_sc_hd__dfrtp_1
X145 clk result_3_ 105 rstn sky130_fd_sc_hd__dfrtp_1
X146 clk result_4_ 107 rstn sky130_fd_sc_hd__dfrtp_1
X147 clk result_5_ 109 rstn sky130_fd_sc_hd__dfrtp_1
X148 clk result_6_ 111 rstn sky130_fd_sc_hd__dfrtp_1
X149 clk result_7_ 113 rstn sky130_fd_sc_hd__dfrtp_1
X150 clk calibrate 96 rstn sky130_fd_sc_hd__dfrtp_1
X151 clk state_0_ 87 rstn sky130_fd_sc_hd__dfrtp_1
X152 clk state_1_ 90 rstn sky130_fd_sc_hd__dfrtp_1
X153 clk state_2_ 93 rstn sky130_fd_sc_hd__dfrtp_1
X154 clk mask_0_ 72 rstn sky130_fd_sc_hd__dfrtp_1
X155 clk mask_1_ 73 rstn sky130_fd_sc_hd__dfrtp_1
X156 clk mask_2_ 74 rstn sky130_fd_sc_hd__dfrtp_1
X157 clk mask_3_ 75 rstn sky130_fd_sc_hd__dfrtp_1
X158 clk mask_4_ 76 rstn sky130_fd_sc_hd__dfrtp_1
X159 clk mask_5_ 77 rstn sky130_fd_sc_hd__dfrtp_1
X160 clk mask_6_ 78 rstn sky130_fd_sc_hd__dfrtp_1
X161 clk mask_7_ 80 rstn sky130_fd_sc_hd__dfrtp_1
X162 clk trim_mask_0_ 65 rstn sky130_fd_sc_hd__dfrtp_1
X163 clk trim_mask_1_ 66 rstn sky130_fd_sc_hd__dfrtp_1
X164 clk trim_mask_2_ 67 rstn sky130_fd_sc_hd__dfrtp_1
X165 clk trim_mask_3_ 68 rstn sky130_fd_sc_hd__dfrtp_1
X166 clk trim_mask_4_ 70 rstn sky130_fd_sc_hd__dfrtp_1
X167 clk trim_val_0_ 54 rstn sky130_fd_sc_hd__dfrtp_1
X168 clk trim_val_1_ 56 rstn sky130_fd_sc_hd__dfrtp_1
X169 clk trim_val_2_ 58 rstn sky130_fd_sc_hd__dfrtp_1
X170 clk trim_val_3_ 60 rstn sky130_fd_sc_hd__dfrtp_1
X171 clk trim_val_4_ 63 rstn sky130_fd_sc_hd__dfrtp_1
X172 clk en_co_clk 47 rstn sky130_fd_sc_hd__dfrtp_1
X173 clk cal_count_0_ 25 rstn sky130_fd_sc_hd__dfstp_2
X174 clk cal_count_1_ 31 rstn sky130_fd_sc_hd__dfstp_2
X175 clk cal_count_2_ 35 rstn sky130_fd_sc_hd__dfstp_2
X176 clk cal_count_3_ 39 rstn sky130_fd_sc_hd__dfrtp_1
X177 clk cal_itt_0_ 10 rstn sky130_fd_sc_hd__dfrtp_1
X178 clk cal_itt_1_ 14 rstn sky130_fd_sc_hd__dfrtp_1
X179 clk cal_itt_2_ 17 rstn sky130_fd_sc_hd__dfrtp_1
X180 clk cal_itt_3_ 19 rstn sky130_fd_sc_hd__dfrtp_1
V0 co_clk Vss DC 0
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
