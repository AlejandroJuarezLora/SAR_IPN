* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT sar_logic clk rstn en comp cal valid result_0_ result_1_ result_2_ result_3_ result_4_ result_5_ result_6_ result_7_ sample ctlp_0_ ctlp_1_ ctlp_2_ ctlp_3_ ctlp_4_ ctlp_5_ ctlp_6_ ctlp_7_ ctln_0_ ctln_1_ ctln_2_ ctln_3_ ctln_4_ ctln_5_ ctln_6_ ctln_7_ trim_0_ trim_1_ trim_2_ trim_3_ trim_4_ trimb_0_ trimb_1_ trimb_2_ trimb_3_ trimb_4_ clkc
X0 1 state_0_ sky130_fd_sc_hd__clkinv_1
X1 2 en sky130_fd_sc_hd__clkinv_1
X2 3 state_0_ state_1_ state_2_ sky130_fd_sc_hd__nor3b_1
X3 4 state_1_ state_0_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X4 5 state_1_ state_2_ state_0_ sky130_fd_sc_hd__and3b_1
X5 6 state_1_ state_2_ state_0_ sky130_fd_sc_hd__nand3b_1
X6 7 state_0_ state_2_ sky130_fd_sc_hd__nor2_1
X7 8 state_1_ 7 sky130_fd_sc_hd__nand2_1
X8 9 6 8 sky130_fd_sc_hd__nand2_1
X9 10 trim_mask_0_ trim_val_0_ sky130_fd_sc_hd__nor2_1
X10 11 10 sky130_fd_sc_hd__clkinv_1
X11 12 trim_val_1_ trim_mask_1_ sky130_fd_sc_hd__nor2_1
X12 13 12 sky130_fd_sc_hd__clkinv_1
X13 14 trim_val_2_ trim_mask_2_ sky130_fd_sc_hd__nor2_1
X14 15 14 sky130_fd_sc_hd__clkinv_1
X15 16 trim_val_3_ trim_mask_3_ sky130_fd_sc_hd__nor2_1
X16 17 16 sky130_fd_sc_hd__clkinv_1
X17 18 trim_val_4_ trim_mask_4_ sky130_fd_sc_hd__nor2_1
X18 19 18 sky130_fd_sc_hd__clkinv_1
X19 20 mask_0_ result_0_ sky130_fd_sc_hd__nor2_1
X20 21 20 sky130_fd_sc_hd__clkinv_1
X21 22 mask_1_ result_1_ sky130_fd_sc_hd__nor2_1
X22 23 22 sky130_fd_sc_hd__clkinv_1
X23 24 mask_2_ result_2_ sky130_fd_sc_hd__nor2_1
X24 25 24 sky130_fd_sc_hd__clkinv_1
X25 26 mask_3_ result_3_ sky130_fd_sc_hd__nor2_1
X26 27 26 sky130_fd_sc_hd__clkinv_1
X27 28 mask_4_ result_4_ sky130_fd_sc_hd__nor2_1
X28 29 28 sky130_fd_sc_hd__clkinv_1
X29 30 mask_5_ result_5_ sky130_fd_sc_hd__nor2_1
X30 31 30 sky130_fd_sc_hd__clkinv_1
X31 32 mask_6_ result_6_ sky130_fd_sc_hd__nor2_1
X32 33 32 sky130_fd_sc_hd__clkinv_1
X33 34 mask_7_ result_7_ sky130_fd_sc_hd__nor2_1
X34 35 34 sky130_fd_sc_hd__clkinv_1
X35 36 cal_itt_0_ cal_itt_1_ sky130_fd_sc_hd__nand2_1
X36 37 cal_itt_3_ cal_itt_0_ cal_itt_1_ cal_itt_2_ sky130_fd_sc_hd__and4b_1
X37 38 trim_mask_0_ 37 sky130_fd_sc_hd__nand2_1
X38 39 cal_itt_0_ 38 6 sky130_fd_sc_hd__a21oi_1
X39 40 state_2_ en 4 sky130_fd_sc_hd__o21ai_0
X40 41 40 sky130_fd_sc_hd__clkinv_1
X41 42 cal_itt_0_ 40 39 sky130_fd_sc_hd__a21o_1
X42 43 cal_itt_0_ cal_itt_1_ sky130_fd_sc_hd__nor2_1
X43 44 cal_itt_1_ 40 sky130_fd_sc_hd__nand2_1
X44 45 trim_mask_0_ 37 36 sky130_fd_sc_hd__a21oi_1
X45 46 6 43 45 44 sky130_fd_sc_hd__o31ai_1
X46 47 cal_itt_2_ 36 sky130_fd_sc_hd__xor2_1
X47 48 38 47 6 sky130_fd_sc_hd__a21oi_1
X48 49 cal_itt_2_ 40 48 sky130_fd_sc_hd__a21o_1
X49 50 cal_itt_0_ cal_itt_1_ cal_itt_2_ 6 sky130_fd_sc_hd__a31oi_1
X50 51 40 50 cal_itt_3_ sky130_fd_sc_hd__o21a_1
X51 52 6 37 sky130_fd_sc_hd__lpflow_inputiso1p_1
X52 53 state_2_ state_0_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X53 54 state_2_ state_1_ state_0_ sky130_fd_sc_hd__nor3b_1
X54 55 en 54 sky130_fd_sc_hd__and2_0
X55 56 cal_count_0_ 52 55 sky130_fd_sc_hd__a21oi_1
X56 57 cal_count_0_ 6 56 sky130_fd_sc_hd__o21ai_0
X57 58 cal_count_0_ cal_count_1_ comp sky130_fd_sc_hd__a21boi_0
X58 59 cal_count_0_ cal_count_1_ sky130_fd_sc_hd__nor2_1
X59 60 comp cal_count_0_ cal_count_1_ sky130_fd_sc_hd__and3b_1
X60 61 58 59 60 sky130_fd_sc_hd__nor3_1
X61 62 cal_count_0_ cal_count_1_ comp sky130_fd_sc_hd__nor3b_1
X62 63 52 61 62 41 cal_count_1_ sky130_fd_sc_hd__o32a_1
X63 64 60 62 sky130_fd_sc_hd__nor2_1
X64 65 cal_count_2_ 64 52 sky130_fd_sc_hd__o21ba_1
X65 66 52 64 cal_count_2_ sky130_fd_sc_hd__o21ai_0
X66 67 40 65 66 sky130_fd_sc_hd__o21ai_0
X67 68 cal_count_3_ 40 sky130_fd_sc_hd__nand2_1
X68 69 62 60 cal_count_2_ sky130_fd_sc_hd__mux2i_1
X69 70 cal_count_3_ 69 sky130_fd_sc_hd__xor2_1
X70 71 52 70 68 sky130_fd_sc_hd__o21ai_0
X71 72 en_co_clk 55 sky130_fd_sc_hd__nor2_1
X72 73 trim_mask_0_ 37 6 sky130_fd_sc_hd__a21oi_1
X73 74 4 53 sky130_fd_sc_hd__nor2_1
X74 75 en_co_clk 74 sky130_fd_sc_hd__nand2_1
X75 76 state_2_ state_1_ state_0_ sky130_fd_sc_hd__and3b_1
X76 77 mask_0_ 76 sky130_fd_sc_hd__lpflow_isobufsrc_1
X77 78 54 73 77 sky130_fd_sc_hd__nor3_1
X78 79 75 78 72 sky130_fd_sc_hd__a21oi_1
X79 80 5 37 sky130_fd_sc_hd__and2_0
X80 81 5 37 sky130_fd_sc_hd__nand2_1
X81 82 state_0_ state_2_ state_1_ sky130_fd_sc_hd__nor3_1
X82 83 state_1_ calibrate 7 sky130_fd_sc_hd__and3_1
X83 84 82 83 sky130_fd_sc_hd__lpflow_inputiso1p_1
X84 85 trim_mask_0_ cal_count_3_ 80 trim_val_0_ sky130_fd_sc_hd__a31oi_1
X85 86 84 85 sky130_fd_sc_hd__nor2_1
X86 87 cal_count_3_ 80 trim_val_1_ sky130_fd_sc_hd__a21oi_1
X87 88 12 84 87 sky130_fd_sc_hd__nor3_1
X88 89 cal_count_3_ 80 trim_val_2_ sky130_fd_sc_hd__a21oi_1
X89 90 14 84 89 sky130_fd_sc_hd__nor3_1
X90 91 cal_count_3_ 80 trim_val_3_ sky130_fd_sc_hd__a21oi_1
X91 92 16 84 91 sky130_fd_sc_hd__nor3_1
X92 93 83 trim_val_4_ sky130_fd_sc_hd__lpflow_isobufsrc_1
X93 94 cal_count_3_ trim_mask_4_ 80 82 93 sky130_fd_sc_hd__a311o_1
X94 95 5 83 52 sky130_fd_sc_hd__o21ai_0
X95 96 trim_mask_1_ 80 95 trim_mask_0_ sky130_fd_sc_hd__a22o_1
X96 97 trim_mask_2_ 80 95 trim_mask_1_ sky130_fd_sc_hd__a22o_1
X97 98 trim_mask_3_ 80 95 trim_mask_2_ sky130_fd_sc_hd__a22o_1
X98 99 trim_mask_4_ 80 95 trim_mask_3_ sky130_fd_sc_hd__a22o_1
X99 100 trim_mask_4_ 81 83 sky130_fd_sc_hd__a21o_1
X100 101 state_1_ en 53 sky130_fd_sc_hd__o21ai_0
X101 102 mask_1_ 76 101 mask_0_ sky130_fd_sc_hd__a22o_1
X102 103 mask_2_ 76 101 mask_1_ sky130_fd_sc_hd__a22o_1
X103 104 mask_3_ 76 101 mask_2_ sky130_fd_sc_hd__a22o_1
X104 105 mask_4_ 76 101 mask_3_ sky130_fd_sc_hd__a22o_1
X105 106 mask_5_ 76 101 mask_4_ sky130_fd_sc_hd__a22o_1
X106 107 mask_6_ 76 101 mask_5_ sky130_fd_sc_hd__a22o_1
X107 108 mask_7_ 76 101 mask_6_ sky130_fd_sc_hd__a22o_1
X108 109 mask_7_ 55 sky130_fd_sc_hd__nor2_1
X109 110 76 109 sky130_fd_sc_hd__nor2_1
X110 111 state_2_ state_1_ state_0_ sky130_fd_sc_hd__a21oi_1
X111 112 state_2_ state_1_ sky130_fd_sc_hd__nand2_1
X112 113 state_2_ state_1_ 73 sky130_fd_sc_hd__a21oi_1
X113 114 2 54 77 111 sky130_fd_sc_hd__a211oi_1
X114 115 trim_mask_0_ 81 113 1 114 sky130_fd_sc_hd__o221ai_1
X115 116 55 77 sky130_fd_sc_hd__nor2_1
X116 117 calibrate 8 112 116 sky130_fd_sc_hd__o211ai_1
X117 118 mask_0_ 76 83 5 sky130_fd_sc_hd__a211oi_1
X118 119 112 118 sky130_fd_sc_hd__nand2_1
X119 120 cal 55 sky130_fd_sc_hd__nand2_1
X120 121 40 73 calibrate sky130_fd_sc_hd__o21ai_0
X121 122 120 121 sky130_fd_sc_hd__nand2_1
X122 123 comp 76 sky130_fd_sc_hd__and2_0
X123 124 mask_0_ 123 result_0_ sky130_fd_sc_hd__a21oi_1
X124 125 55 124 sky130_fd_sc_hd__nor2_1
X125 126 mask_1_ 123 result_1_ sky130_fd_sc_hd__a21oi_1
X126 127 55 126 sky130_fd_sc_hd__nor2_1
X127 128 mask_2_ 123 result_2_ sky130_fd_sc_hd__a21oi_1
X128 129 55 128 sky130_fd_sc_hd__nor2_1
X129 130 mask_3_ 123 result_3_ sky130_fd_sc_hd__a21oi_1
X130 131 55 130 sky130_fd_sc_hd__nor2_1
X131 132 mask_4_ 123 result_4_ sky130_fd_sc_hd__a21oi_1
X132 133 55 132 sky130_fd_sc_hd__nor2_1
X133 134 mask_5_ 123 result_5_ sky130_fd_sc_hd__a21oi_1
X134 135 55 134 sky130_fd_sc_hd__nor2_1
X135 136 mask_6_ 123 result_6_ sky130_fd_sc_hd__a21oi_1
X136 137 55 136 sky130_fd_sc_hd__nor2_1
X137 138 mask_7_ 123 result_7_ sky130_fd_sc_hd__a21oi_1
X138 139 55 138 sky130_fd_sc_hd__nor2_1
X139 140 clk en_co_clk sky130_fd_sc_hd__lpflow_isobufsrc_1
X140 state_0_ clk 115 rstn sky130_fd_sc_hd__dfrtp_1
X141 state_1_ clk 117 rstn sky130_fd_sc_hd__dfrtp_1
X142 state_2_ clk 119 rstn sky130_fd_sc_hd__dfrtp_1
X143 mask_0_ clk 102 rstn sky130_fd_sc_hd__dfrtp_1
X144 mask_1_ clk 103 rstn sky130_fd_sc_hd__dfrtp_1
X145 mask_2_ clk 104 rstn sky130_fd_sc_hd__dfrtp_1
X146 mask_3_ clk 105 rstn sky130_fd_sc_hd__dfrtp_1
X147 mask_4_ clk 106 rstn sky130_fd_sc_hd__dfrtp_1
X148 mask_5_ clk 107 rstn sky130_fd_sc_hd__dfrtp_1
X149 mask_6_ clk 108 rstn sky130_fd_sc_hd__dfrtp_1
X150 mask_7_ clk 110 rstn sky130_fd_sc_hd__dfrtp_1
X151 trim_mask_0_ clk 96 rstn sky130_fd_sc_hd__dfrtp_1
X152 trim_mask_1_ clk 97 rstn sky130_fd_sc_hd__dfrtp_1
X153 trim_mask_2_ clk 98 rstn sky130_fd_sc_hd__dfrtp_1
X154 trim_mask_3_ clk 99 rstn sky130_fd_sc_hd__dfrtp_1
X155 trim_mask_4_ clk 100 rstn sky130_fd_sc_hd__dfrtp_1
X156 trim_val_0_ clk 86 rstn sky130_fd_sc_hd__dfrtp_1
X157 trim_val_1_ clk 88 rstn sky130_fd_sc_hd__dfrtp_1
X158 trim_val_2_ clk 90 rstn sky130_fd_sc_hd__dfrtp_1
X159 trim_val_3_ clk 92 rstn sky130_fd_sc_hd__dfrtp_1
X160 trim_val_4_ clk 94 rstn sky130_fd_sc_hd__dfrtp_1
X161 en_co_clk clk 79 rstn sky130_fd_sc_hd__dfrtp_1
X162 cal_count_0_ clk 57 rstn sky130_fd_sc_hd__dfstp_2
X163 cal_count_1_ clk 63 rstn sky130_fd_sc_hd__dfstp_2
X164 cal_count_2_ clk 67 rstn sky130_fd_sc_hd__dfstp_2
X165 cal_count_3_ clk 71 rstn sky130_fd_sc_hd__dfrtp_1
X166 cal_itt_0_ clk 42 rstn sky130_fd_sc_hd__dfrtp_1
X167 cal_itt_1_ clk 46 rstn sky130_fd_sc_hd__dfrtp_1
X168 cal_itt_2_ clk 49 rstn sky130_fd_sc_hd__dfrtp_1
X169 cal_itt_3_ clk 51 rstn sky130_fd_sc_hd__dfrtp_1
X170 result_0_ clk 125 rstn sky130_fd_sc_hd__dfrtp_1
X171 result_1_ clk 127 rstn sky130_fd_sc_hd__dfrtp_1
X172 result_2_ clk 129 rstn sky130_fd_sc_hd__dfrtp_1
X173 result_3_ clk 131 rstn sky130_fd_sc_hd__dfrtp_1
X174 result_4_ clk 133 rstn sky130_fd_sc_hd__dfrtp_1
X175 result_5_ clk 135 rstn sky130_fd_sc_hd__dfrtp_1
X176 result_6_ clk 137 rstn sky130_fd_sc_hd__dfrtp_1
X177 result_7_ clk 139 rstn sky130_fd_sc_hd__dfrtp_1
X178 calibrate clk 122 rstn sky130_fd_sc_hd__dfrtp_1
V0 141 Vss DC 0
V1 142 Vss DC 0
V2 143 Vss DC 0
V3 144 Vss DC 0
V4 145 Vss DC 0
V5 146 Vss DC 0
V6 147 Vss DC 0
V7 148 Vss DC 0
V8 149 Vss DC 0
V9 150 Vss DC 0
V10 151 Vss DC 0
V11 152 Vss DC 0
V12 153 Vss DC 0
V13 154 Vss DC 0
V14 155 Vss DC 0
V15 156 Vss DC 0
V16 157 Vss DC 0
V17 158 Vss DC 0
V18 159 Vss DC 0
V19 160 Vss DC 0
V20 161 Vss DC 0
V21 162 Vss DC 0
V22 163 Vss DC 0
V23 164 Vss DC 0
V24 165 Vss DC 0
V25 166 Vss DC 0
V26 167 Vss DC 0
V27 168 Vss DC 0
V28 169 Vss DC 0
V29 170 Vss DC 0
V30 171 Vss DC 0
V31 172 Vss DC 0
V32 173 Vss DC 0
V33 174 Vss DC 0
V34 175 Vss DC 0
V35 176 Vss DC 0
V36 177 Vss DC 0
V37 178 Vss DC 0
V38 179 Vss DC 0
V39 180 Vss DC 0
V40 181 Vss DC 0
V41 182 Vss DC 0
V42 183 Vss DC 0
V43 184 Vss DC 0
V44 185 Vss DC 0
V45 186 Vss DC 0
V46 187 Vss DC 0
V47 188 Vss DC 0
V48 189 Vss DC 0
V49 190 Vss DC 0
V50 191 Vss DC 0
V51 192 Vss DC 0
V52 193 Vss DC 0
V53 194 Vss DC 0
V54 195 Vdd DC 0
V55 196 Vdd DC 0
V56 197 Vdd DC 0
V57 198 Vdd DC 0
V58 199 Vdd DC 0
V59 200 Vdd DC 0
V60 201 Vdd DC 0
V61 202 Vdd DC 0
V62 203 Vdd DC 0
V63 204 Vdd DC 0
V64 205 Vdd DC 0
V65 206 Vdd DC 0
V66 207 Vdd DC 0
V67 208 Vdd DC 0
V68 209 Vdd DC 0
V69 210 Vdd DC 0
V70 211 Vdd DC 0
V71 212 Vdd DC 0
V72 213 Vdd DC 0
V73 214 Vdd DC 0
V74 215 Vdd DC 0
V75 216 217 DC 0
V76 218 cal_itt_3_ DC 0
V77 219 state_0_ DC 0
V78 220 state_1_ DC 0
V79 221 state_0_ DC 0
V80 222 state_2_ DC 0
V81 223 state_1_ DC 0
V82 224 225 DC 0
V83 226 Vss DC 0
V84 227 228 DC 0
V85 229 230 DC 0
V86 231 Vss DC 0
V87 232 Vss DC 0
V88 233 234 DC 0
V89 235 236 DC 0
V90 237 238 DC 0
V91 239 Vss DC 0
V92 240 241 DC 0
V93 242 Vss DC 0
V94 243 Vdd DC 0
V95 244 Vdd DC 0
V96 245 calibrate DC 0
V97 246 en DC 0
V98 247 Vss DC 0
V99 248 249 DC 0
V100 250 Vss DC 0
V101 251 Vss DC 0
V102 252 Vss DC 0
V103 253 Vss DC 0
V104 254 255 DC 0
V105 256 257 DC 0
V106 258 259 DC 0
V107 260 261 DC 0
V108 262 263 DC 0
V109 264 249 DC 0
V110 265 266 DC 0
V111 267 266 DC 0
V112 268 266 DC 0
V113 269 266 DC 0
V114 270 266 DC 0
V115 271 266 DC 0
V116 272 266 DC 0
V117 273 266 DC 0
V118 274 266 DC 0
V119 275 266 DC 0
V120 276 266 DC 0
V121 277 266 DC 0
V122 278 266 DC 0
V123 279 266 DC 0
V124 280 266 DC 0
V125 281 266 DC 0
V126 282 266 DC 0
V127 283 266 DC 0
V128 284 266 DC 0
V129 285 266 DC 0
V130 286 266 DC 0
V131 287 266 DC 0
V132 288 266 DC 0
V133 289 266 DC 0
V134 290 266 DC 0
V135 291 266 DC 0
V136 292 266 DC 0
V137 293 cal_count_0_ DC 0
V138 294 295 DC 0
V139 296 297 DC 0
V140 298 Vss DC 0
V141 299 Vss DC 0
V142 300 Vss DC 0
V143 301 Vss DC 0
V144 302 Vss DC 0
V145 303 Vss DC 0
V146 304 Vss DC 0
V147 305 Vss DC 0
V148 306 Vss DC 0
V149 307 Vss DC 0
V150 308 Vss DC 0
V151 309 Vss DC 0
V152 310 Vss DC 0
V153 311 Vss DC 0
V154 312 Vss DC 0
V155 313 Vss DC 0
V156 314 Vss DC 0
V157 315 Vss DC 0
V158 316 Vss DC 0
V159 317 Vss DC 0
V160 318 Vss DC 0
V161 319 Vss DC 0
V162 320 Vss DC 0
V163 321 Vss DC 0
V164 322 Vss DC 0
V165 323 Vss DC 0
V166 324 Vss DC 0
V167 325 Vss DC 0
V168 326 cal_itt_0_ DC 0
V169 327 328 DC 0
V170 329 Vss DC 0
V171 330 Vss DC 0
V172 331 Vss DC 0
V173 332 Vss DC 0
V174 333 Vss DC 0
V175 334 Vss DC 0
V176 335 Vss DC 0
V177 336 Vss DC 0
V178 337 Vss DC 0
V179 338 Vss DC 0
V180 339 Vss DC 0
V181 340 Vss DC 0
V182 341 Vss DC 0
V183 342 Vss DC 0
V184 343 Vss DC 0
V185 344 Vss DC 0
V186 345 Vss DC 0
V187 346 Vss DC 0
V188 347 Vss DC 0
V189 348 Vss DC 0
V190 349 Vss DC 0
V191 350 Vss DC 0
V192 351 Vss DC 0
V193 352 Vss DC 0
V194 353 Vss DC 0
V195 354 Vss DC 0
V196 355 Vss DC 0
V197 356 Vss DC 0
V198 357 cal_count_0_ DC 0
V199 358 295 DC 0
V200 359 360 DC 0
V201 361 362 DC 0
V202 363 362 DC 0
V203 364 362 DC 0
V204 365 362 DC 0
V205 366 362 DC 0
V206 367 362 DC 0
V207 368 362 DC 0
V208 369 362 DC 0
V209 370 362 DC 0
V210 371 362 DC 0
V211 372 362 DC 0
V212 373 362 DC 0
V213 374 362 DC 0
V214 375 362 DC 0
V215 376 362 DC 0
V216 377 362 DC 0
V217 378 362 DC 0
V218 379 362 DC 0
V219 380 362 DC 0
V220 381 362 DC 0
V221 382 362 DC 0
V222 383 362 DC 0
V223 384 362 DC 0
V224 385 362 DC 0
V225 386 362 DC 0
V226 387 362 DC 0
V227 388 362 DC 0
V228 389 362 DC 0
V229 390 cal_count_0_ DC 0
V230 391 cal_count_1_ DC 0
V231 392 cal_count_2_ DC 0
V232 393 Vdd DC 0
V233 394 Vdd DC 0
V234 395 Vdd DC 0
V235 396 Vdd DC 0
V236 397 Vdd DC 0
V237 398 Vdd DC 0
V238 399 Vdd DC 0
V239 400 Vdd DC 0
V240 401 Vdd DC 0
V241 402 Vdd DC 0
V242 403 Vdd DC 0
V243 404 Vdd DC 0
V244 405 Vdd DC 0
V245 406 Vdd DC 0
V246 407 Vdd DC 0
V247 408 Vdd DC 0
V248 409 Vdd DC 0
V249 410 Vdd DC 0
V250 411 Vdd DC 0
V251 412 Vdd DC 0
V252 413 Vdd DC 0
V253 414 Vdd DC 0
V254 415 Vdd DC 0
V255 416 Vdd DC 0
V256 417 Vdd DC 0
V257 418 Vdd DC 0
V258 419 Vdd DC 0
V259 420 Vdd DC 0
V260 421 cal_count_0_ DC 0
V261 422 423 DC 0
V262 424 423 DC 0
V263 425 423 DC 0
V264 426 423 DC 0
V265 427 423 DC 0
V266 428 423 DC 0
V267 429 423 DC 0
V268 430 423 DC 0
V269 431 423 DC 0
V270 432 423 DC 0
V271 433 423 DC 0
V272 434 423 DC 0
V273 435 423 DC 0
V274 436 423 DC 0
V275 437 423 DC 0
V276 438 423 DC 0
V277 439 423 DC 0
V278 440 423 DC 0
V279 441 423 DC 0
V280 442 423 DC 0
V281 443 423 DC 0
V282 444 423 DC 0
V283 445 423 DC 0
V284 446 423 DC 0
V285 447 423 DC 0
V286 448 423 DC 0
V287 449 423 DC 0
V288 450 423 DC 0
V289 451 cal_count_0_ DC 0
V290 452 453 DC 0
V291 454 Vdd DC 0
V292 455 Vdd DC 0
V293 456 Vdd DC 0
V294 457 Vdd DC 0
V295 458 Vdd DC 0
V296 459 Vdd DC 0
V297 460 Vdd DC 0
V298 461 Vdd DC 0
V299 462 Vdd DC 0
V300 463 Vdd DC 0
V301 464 Vdd DC 0
V302 465 Vdd DC 0
V303 466 Vdd DC 0
V304 467 Vdd DC 0
V305 468 Vdd DC 0
V306 469 Vdd DC 0
V307 470 Vdd DC 0
V308 471 Vdd DC 0
V309 472 Vdd DC 0
V310 473 Vdd DC 0
V311 474 Vdd DC 0
V312 475 Vdd DC 0
V313 476 Vdd DC 0
V314 477 Vdd DC 0
V315 478 Vdd DC 0
V316 479 Vdd DC 0
V317 480 Vdd DC 0
V318 481 Vdd DC 0
V319 co_clk Vss DC 0
V320 482 cal_itt_3_ DC 0
V321 valid 3 DC 0
V322 483 state_0_ DC 0
V323 484 state_2_ DC 0
V324 485 state_1_ DC 0
V325 sample 9 DC 0
V326 486 cal_itt_0_ DC 0
V327 487 trim_mask_0_ DC 0
V328 488 cal_itt_1_ DC 0
V329 489 cal_itt_2_ DC 0
V330 490 comp DC 0
V331 491 en DC 0
V332 492 cal_count_0_ DC 0
V333 493 cal_count_1_ DC 0
V334 494 cal_count_2_ DC 0
V335 495 cal_count_3_ DC 0
V336 496 en_co_clk DC 0
V337 497 mask_0_ DC 0
V338 trim_0_ 11 DC 0
V339 498 trim_val_0_ DC 0
V340 trim_1_ 13 DC 0
V341 499 trim_val_1_ DC 0
V342 trim_2_ 15 DC 0
V343 500 trim_val_2_ DC 0
V344 trim_3_ 17 DC 0
V345 501 trim_val_3_ DC 0
V346 trim_4_ 19 DC 0
V347 502 trim_val_4_ DC 0
V348 503 calibrate DC 0
V349 504 trim_mask_1_ DC 0
V350 505 trim_mask_2_ DC 0
V351 506 trim_mask_3_ DC 0
V352 507 trim_mask_4_ DC 0
V353 508 mask_1_ DC 0
V354 509 mask_2_ DC 0
V355 510 mask_3_ DC 0
V356 511 mask_4_ DC 0
V357 512 mask_5_ DC 0
V358 513 mask_6_ DC 0
V359 514 mask_7_ DC 0
V360 515 cal DC 0
V361 516 result_0_ DC 0
V362 ctlp_0_ 21 DC 0
V363 517 result_1_ DC 0
V364 ctlp_1_ 23 DC 0
V365 518 result_2_ DC 0
V366 ctlp_2_ 25 DC 0
V367 519 result_3_ DC 0
V368 ctlp_3_ 27 DC 0
V369 520 result_4_ DC 0
V370 ctlp_4_ 29 DC 0
V371 521 result_5_ DC 0
V372 ctlp_5_ 31 DC 0
V373 522 result_6_ DC 0
V374 ctlp_6_ 33 DC 0
V375 523 result_7_ DC 0
V376 ctlp_7_ 35 DC 0
V377 524 42 DC 0
V378 525 46 DC 0
V379 526 49 DC 0
V380 527 51 DC 0
V381 528 57 DC 0
V382 529 63 DC 0
V383 530 67 DC 0
V384 531 71 DC 0
V385 532 79 DC 0
V386 533 86 DC 0
V387 534 88 DC 0
V388 535 90 DC 0
V389 536 92 DC 0
V390 537 94 DC 0
V391 538 96 DC 0
V392 539 97 DC 0
V393 540 98 DC 0
V394 541 99 DC 0
V395 542 100 DC 0
V396 543 102 DC 0
V397 544 103 DC 0
V398 545 104 DC 0
V399 546 105 DC 0
V400 547 106 DC 0
V401 548 107 DC 0
V402 549 108 DC 0
V403 550 110 DC 0
V404 551 115 DC 0
V405 552 117 DC 0
V406 553 119 DC 0
V407 554 122 DC 0
V408 555 125 DC 0
V409 556 127 DC 0
V410 557 129 DC 0
V411 558 131 DC 0
V412 559 133 DC 0
V413 560 135 DC 0
V414 561 137 DC 0
V415 562 139 DC 0
V416 563 clk DC 0
V417 trimb_0_ 10 DC 0
V418 trimb_1_ 12 DC 0
V419 trimb_2_ 14 DC 0
V420 trimb_3_ 16 DC 0
V421 trimb_4_ 18 DC 0
V422 ctln_0_ 20 DC 0
V423 ctln_1_ 22 DC 0
V424 ctln_2_ 24 DC 0
V425 ctln_3_ 26 DC 0
V426 ctln_4_ 28 DC 0
V427 ctln_5_ 30 DC 0
V428 ctln_6_ 32 DC 0
V429 ctln_7_ 34 DC 0
V430 clkc 140 DC 0
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
