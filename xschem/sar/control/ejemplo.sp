* SPICE netlist generated by Yosys 0.9 (git sha1 1979e0b)

.SUBCKT sar_logic clk rstn en comp cal valid result.0 result.1 result.2 result.3 result.4 result.5 result.6 result.7 sample ctlp.0 ctlp.1 ctlp.2 ctlp.3 ctlp.4 ctlp.5 ctlp.6 ctlp.7 ctln.0 ctln.1 ctln.2 ctln.3 ctln.4 ctln.5 ctln.6 ctln.7 trim.0 trim.1 trim.2 trim.3 trim.4 trimb.0 trimb.1 trimb.2 trimb.3 trimb.4 clkc
X0 ctln.4 ctlp.4 __NOT_
X1 result.5 mask.5 ctln.5 __NOR_
X2 ctln.5 ctlp.5 __NOT_
X3 result.6 mask.6 ctln.6 __NOR_
X4 ctln.6 ctlp.6 __NOT_
X5 result.7 mask.7 ctln.7 __NOR_
X6 ctln.7 ctlp.7 __NOT_
X7 state.2 1 2 __ANDNOT_
X8 1 state.2 3 __OR_
X9 3 2 4 __ANDNOT_
X10 2 5 __NOT_
X11 trim_mask.0 cal_itt.0 6 __NAND_
X12 cal_itt.1 cal_itt.0 7 __AND_
X13 cal_itt.3 cal_itt.2 8 __ORNOT_
X14 8 7 9 __ORNOT_
X15 6 cal_itt.0 9 10 __MUX_
X16 en cal_itt.0 11 __ORNOT_
X17 11 3 10 5 12 __OAI4_
X18 12 cal_itt.0 4 13.0 __MUX_
X19 7 8 14 __ANDNOT_
X20 cal_itt.1 trim_mask.0 15 __NAND_
X21 cal_itt.1 cal_itt.0 16 __XNOR_
X22 16 15 14 17 __MUX_
X23 en cal_itt.1 18 __ORNOT_
X24 18 3 17 5 19 __OAI4_
X25 19 cal_itt.1 4 13.1 __MUX_
X26 cal_itt.2 trim_mask.0 20 __NAND_
X27 7 cal_itt.2 21 __XNOR_
X28 21 20 14 22 __MUX_
X29 en cal_itt.2 23 __ORNOT_
X30 23 3 22 5 24 __OAI4_
X31 24 cal_itt.2 4 13.2 __MUX_
X32 trim_mask.0 cal_itt.3 25 __AND_
X33 cal_itt.3 26 __NOT_
X34 7 cal_itt.2 26 27 __AOI3_
X35 25 14 27 28 __AOI3_
X36 en cal_itt.3 29 __ORNOT_
X37 29 3 28 5 30 __OAI4_
X38 30 cal_itt.3 4 13.3 __MUX_
X39 cal_count.0 comp 31 __OR_
X40 comp cal_count.0 32 __ANDNOT_
X41 31 32 33 __ANDNOT_
X42 33 14 34 __ANDNOT_
X43 cal_count.0 en 35 __NOR_
X44 35 3 34 5 36 __OAI4_
X45 36 cal_count.0 4 37.0 __MUX_
X46 cal_count.1 cal_count.0 38 __XNOR_
X47 cal_count.1 cal_count.0 39 __XOR_
X48 38 39 comp 40 __MUX_
X49 40 14 41 __ANDNOT_
X50 cal_count.1 en 42 __NOR_
X51 42 3 41 5 43 __OAI4_
X52 43 cal_count.1 4 37.1 __MUX_
X53 cal_count.1 cal_count.0 44 __NAND_
X54 44 cal_count.2 45 __XOR_
X55 cal_count.1 cal_count.0 46 __OR_
X56 46 cal_count.2 47 __XOR_
X57 45 47 comp 48 __MUX_
X58 48 9 5 49 __AOI3_
X59 en 50 __NOT_
X60 cal_count.2 51 __NOT_
X61 51 50 3 52 __AOI3_
X62 52 49 53 __OR_
X63 53 cal_count.2 4 37.2 __MUX_
X64 cal_count.3 54 __NOT_
X65 cal_count.2 44 55 __ANDNOT_
X66 55 54 56 __XOR_
X67 51 46 57 __ANDNOT_
X68 57 54 58 __XOR_
X69 56 58 comp 59 __MUX_
X70 59 14 60 __OR_
X71 en cal_count.3 61 __ORNOT_
X72 61 3 60 5 62 __OAI4_
X73 62 cal_count.3 4 37.3 __MUX_
X74 state.1 state.0 63 __NAND_
X75 63 state.2 1 64 __OAI3_
X76 63 state.2 65 __OR_
X77 trim_mask.0 66 __NOT_
X78 9 66 en_co_clk 67 __OAI3_
X79 mask.0 en_co_clk 68 __ORNOT_
X80 68 65 67 5 69 __OAI4_
X81 en_co_clk en 70 __OR_
X82 70 3 71 __ANDNOT_
X83 71 69 72 __OR_
X84 en_co_clk 72 64 73 __MUX_
X85 74 state.2 75 __NOR_
X86 76 75 77 __ANDNOT_
X87 78 state.2 79 __OR_
X88 trim_val.0 80 __NOT_
X89 cal_count.3 cal_count.2 81 __OR_
X90 cal_count.2 cal_count.3 82 __ANDNOT_
X91 81 82 83 __ANDNOT_
X92 80 trimb.0 83 84 __MUX_
X93 84 80 9 85 __MUX_
X94 calibrate trim_val.0 86 __ORNOT_
X95 86 79 85 5 87 __OAI4_
X96 87 trim_val.0 77 88.0 __MUX_
X97 trim_val.1 89 __NOT_
X98 89 trimb.1 83 90 __MUX_
X99 90 89 9 91 __MUX_
X100 calibrate trim_val.1 92 __ORNOT_
X101 92 79 91 5 93 __OAI4_
X102 93 trim_val.1 77 88.1 __MUX_
X103 trim_val.2 94 __NOT_
X104 94 trimb.2 83 95 __MUX_
X105 95 94 9 96 __MUX_
X106 calibrate trim_val.2 97 __ORNOT_
X107 97 79 96 5 98 __OAI4_
X108 98 trim_val.2 77 88.2 __MUX_
X109 trim_val.3 99 __NOT_
X110 99 trimb.3 83 100 __MUX_
X111 100 99 9 101 __MUX_
X112 calibrate trim_val.3 102 __ORNOT_
X113 102 79 101 5 103 __OAI4_
X114 103 trim_val.3 77 88.3 __MUX_
X115 trim_val.4 104 __NOT_
X116 104 trimb.4 83 105 __MUX_
X117 105 104 9 106 __MUX_
X118 calibrate trim_val.4 107 __ORNOT_
X119 107 79 106 5 108 __OAI4_
X120 108 75 109 __OR_
X121 109 trim_val.4 77 88.4 __MUX_
X122 trim_mask.1 110 __NOT_
X123 110 66 9 111 __MUX_
X124 calibrate trim_mask.0 112 __ORNOT_
X125 112 79 111 5 113 __OAI4_
X126 113 trim_mask.0 76 114.0 __MUX_
X127 trim_mask.2 115 __NOT_
X128 115 110 9 116 __MUX_
X129 calibrate trim_mask.1 117 __ORNOT_
X130 117 79 116 5 118 __OAI4_
X131 118 trim_mask.1 76 114.1 __MUX_
X132 trim_mask.3 119 __NOT_
X133 119 115 9 120 __MUX_
X134 calibrate trim_mask.2 121 __ORNOT_
X135 121 79 120 5 122 __OAI4_
X136 122 trim_mask.2 76 114.2 __MUX_
X137 trim_mask.4 123 __NOT_
X138 123 119 9 124 __MUX_
X139 calibrate trim_mask.3 125 __ORNOT_
X140 125 79 124 5 126 __OAI4_
X141 126 trim_mask.3 76 114.3 __MUX_
X142 14 123 127 __OR_
X143 trim_mask.4 calibrate 128 __NOR_
X144 128 79 127 5 129 __OAI4_
X145 129 trim_mask.4 76 114.4 __MUX_
X146 state.2 state.0 130 __ORNOT_
X147 mask.1 131 __NOT_
X148 en mask.0 132 __ORNOT_
X149 132 3 65 131 133 __OAI4_
X150 133 mask.0 130 134.0 __MUX_
X151 mask.2 135 __NOT_
X152 en mask.1 136 __ORNOT_
X153 136 3 65 135 137 __OAI4_
X154 137 mask.1 130 134.1 __MUX_
X155 mask.3 138 __NOT_
X156 en mask.2 139 __ORNOT_
X157 139 3 65 138 140 __OAI4_
X158 140 mask.2 130 134.2 __MUX_
X159 mask.4 141 __NOT_
X160 en mask.3 142 __ORNOT_
X161 142 3 65 141 143 __OAI4_
X162 143 mask.3 130 134.3 __MUX_
X163 mask.5 144 __NOT_
X164 en mask.4 145 __ORNOT_
X165 145 3 65 144 146 __OAI4_
X166 146 mask.4 130 134.4 __MUX_
X167 mask.6 147 __NOT_
X168 en mask.5 148 __ORNOT_
X169 148 3 65 147 149 __OAI4_
X170 149 mask.5 130 134.5 __MUX_
X171 mask.7 150 __NOT_
X172 en mask.6 151 __ORNOT_
X173 151 3 65 150 152 __OAI4_
X174 152 mask.6 130 134.6 __MUX_
X175 150 50 3 153 __AOI3_
X176 153 mask.7 130 134.7 __MUX_
X177 75 valid 154 __OR_
X178 154 2 155 __OR_
X179 65 79 156 __NAND_
X180 156 155 157 __OR_
X181 3 157 158 __ANDNOT_
X182 66 state.0 9 159 __MUX_
X183 159 2 154 160 __AOI3_
X184 mask.0 state.0 161 __ORNOT_
X185 161 65 79 162 __OAI3_
X186 160 162 163 __ANDNOT_
X187 3 en 163 164 __OAI3_
X188 164 state.0 158 165.0 __MUX_
X189 state.1 14 166 __ANDNOT_
X190 mask.0 state.1 167 __ORNOT_
X191 167 65 79 calibrate 168 __OAI4_
X192 166 2 168 169 __AOI3_
X193 3 50 169 170 __OAI3_
X194 170 state.1 158 165.1 __MUX_
X195 calibrate 171 __NOT_
X196 mask.0 state.2 172 __NOR_
X197 172 65 79 171 173 __OAI4_
X198 173 2 174 __OR_
X199 174 state.2 158 165.2 __MUX_
X200 9 66 calibrate 175 __OAI3_
X201 cal 176 __NOT_
X202 171 176 en 177 __MUX_
X203 177 3 175 5 178 __OAI4_
X204 178 calibrate 4 179 __MUX_
X205 mask.0 comp result.0 180 __AOI3_
X206 en result.0 181 __ORNOT_
X207 181 3 180 65 182 __OAI4_
X208 182 result.0 130 183.0 __MUX_
X209 mask.1 comp result.1 184 __AOI3_
X210 en result.1 185 __ORNOT_
X211 185 3 184 65 186 __OAI4_
X212 186 result.1 130 183.1 __MUX_
X213 mask.2 comp result.2 187 __AOI3_
X214 en result.2 188 __ORNOT_
X215 188 3 187 65 189 __OAI4_
X216 189 result.2 130 183.2 __MUX_
X217 mask.3 comp result.3 190 __AOI3_
X218 en result.3 191 __ORNOT_
X219 191 3 190 65 192 __OAI4_
X220 192 result.3 130 183.3 __MUX_
X221 mask.4 comp result.4 193 __AOI3_
X222 en result.4 194 __ORNOT_
X223 194 3 193 65 195 __OAI4_
X224 195 result.4 130 183.4 __MUX_
X225 mask.5 comp result.5 196 __AOI3_
X226 en result.5 197 __ORNOT_
X227 197 3 196 65 198 __OAI4_
X228 198 result.5 130 183.5 __MUX_
X229 mask.6 comp result.6 199 __AOI3_
X230 en result.6 200 __ORNOT_
X231 200 3 199 65 201 __OAI4_
X232 201 result.6 130 183.6 __MUX_
X233 mask.7 comp result.7 202 __AOI3_
X234 en result.7 203 __ORNOT_
X235 203 3 202 65 204 __OAI4_
X236 204 result.7 130 183.7 __MUX_
X237 en_co_clk clk clkc __ANDNOT_
X238 state.1 state.0 74 __OR_
X239 state.2 74 valid __ANDNOT_
X240 state.1 state.0 1 __ORNOT_
X241 state.0 state.1 78 __ORNOT_
X242 78 1 state.2 76 __MUX_
X243 76 sample __NOT_
X244 trim_val.0 trim_mask.0 trimb.0 __NOR_
X245 trimb.0 trim.0 __NOT_
X246 trim_mask.1 trim_val.1 trimb.1 __NOR_
X247 trimb.1 trim.1 __NOT_
X248 trim_mask.2 trim_val.2 trimb.2 __NOR_
X249 trimb.2 trim.2 __NOT_
X250 trim_mask.3 trim_val.3 trimb.3 __NOR_
X251 trimb.3 trim.3 __NOT_
X252 trim_mask.4 trim_val.4 trimb.4 __NOR_
X253 trimb.4 trim.4 __NOT_
X254 result.0 mask.0 ctln.0 __NOR_
X255 ctln.0 ctlp.0 __NOT_
X256 result.1 mask.1 ctln.1 __NOR_
X257 ctln.1 ctlp.1 __NOT_
X258 result.2 mask.2 ctln.2 __NOR_
X259 ctln.2 ctlp.2 __NOT_
X260 result.3 mask.3 ctln.3 __NOR_
X261 ctln.3 ctlp.3 __NOT_
X262 result.4 mask.4 ctln.4 __NOR_
X263 clk 183.0 result.0 rstn __DFF_PN0_
X264 clk 183.1 result.1 rstn __DFF_PN0_
X265 clk 183.2 result.2 rstn __DFF_PN0_
X266 clk 183.3 result.3 rstn __DFF_PN0_
X267 clk 183.4 result.4 rstn __DFF_PN0_
X268 clk 183.5 result.5 rstn __DFF_PN0_
X269 clk 183.6 result.6 rstn __DFF_PN0_
X270 clk 183.7 result.7 rstn __DFF_PN0_
X271 clk 179 calibrate rstn __DFF_PN0_
X272 clk 165.0 state.0 rstn __DFF_PN0_
X273 clk 165.1 state.1 rstn __DFF_PN0_
X274 clk 165.2 state.2 rstn __DFF_PN0_
X275 clk 134.0 mask.0 rstn __DFF_PN0_
X276 clk 134.1 mask.1 rstn __DFF_PN0_
X277 clk 134.2 mask.2 rstn __DFF_PN0_
X278 clk 134.3 mask.3 rstn __DFF_PN0_
X279 clk 134.4 mask.4 rstn __DFF_PN0_
X280 clk 134.5 mask.5 rstn __DFF_PN0_
X281 clk 134.6 mask.6 rstn __DFF_PN0_
X282 clk 134.7 mask.7 rstn __DFF_PN0_
X283 clk 114.0 trim_mask.0 rstn __DFF_PN0_
X284 clk 114.1 trim_mask.1 rstn __DFF_PN0_
X285 clk 114.2 trim_mask.2 rstn __DFF_PN0_
X286 clk 114.3 trim_mask.3 rstn __DFF_PN0_
X287 clk 114.4 trim_mask.4 rstn __DFF_PN0_
X288 clk 88.0 trim_val.0 rstn __DFF_PN0_
X289 clk 88.1 trim_val.1 rstn __DFF_PN0_
X290 clk 88.2 trim_val.2 rstn __DFF_PN0_
X291 clk 88.3 trim_val.3 rstn __DFF_PN0_
X292 clk 88.4 trim_val.4 rstn __DFF_PN0_
X293 clk 73 en_co_clk rstn __DFF_PN0_
X294 clk 37.0 cal_count.0 rstn __DFF_PN1_
X295 clk 37.1 cal_count.1 rstn __DFF_PN1_
X296 clk 37.2 cal_count.2 rstn __DFF_PN1_
X297 clk 37.3 cal_count.3 rstn __DFF_PN0_
X298 clk 13.0 cal_itt.0 rstn __DFF_PN0_
X299 clk 13.1 cal_itt.1 rstn __DFF_PN0_
X300 clk 13.2 cal_itt.2 rstn __DFF_PN0_
X301 clk 13.3 cal_itt.3 rstn __DFF_PN0_
V0 co_clk Vss DC 0
.ENDS sar_logic

************************
* end of SPICE netlist *
************************
