** sch_path: xschem/sar/comparator/trimcap.sch
**.subckt trimcap cp cn
*.iopin cp
*.iopin cn
XC2 cp cn sky130_fd_pr__cap_mim_m3_1 W=2 L=2 MF=1 m=1
**.ends
.end
